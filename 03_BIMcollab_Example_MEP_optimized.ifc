Properties of the parts of a building model (IFC2X3), part 1 of 14

# File
Description: ViewDefinition [CoordinationView]
File name: 03_BIMcollab_Example_MEP.ifc
Time: 2017-03-01T15:48:09
Author: rgeenen
Organization: Data Design System ASA
Written by: DDS-IFC v2.0
Made in: DDS-CAD Version 9 Win32 build 13/11-2013 (Solibri IFC Optimizer)
Authorization: DDS

# IfcProject, BIMcolalb example project
Phase: Design

# IfcSite, Construction Site
RefLatitude: 51, 27, 0, 0; RefLongitude: 5, 29, 0, 0; RefElevation: -1000 mm

# IfcBuilding, Hybrid BIM-office
ElevationOfTerrain: 0.5 mm

# IfcBuildingStorey (5)
In: Hybrid BIM-office
Name | Description | Elevation (mm)
-01 Foundation | -01 Foundation | -800
00 Ground floor | 00 Ground floor | 0
01 First floor | 01 First floor | 3500
02 Second floor | 02 Second floor | 7000
03. Roof | 03. Roof | 10500

# IfcDistributionControlElement: S2-111118-002 (4)
In: 01 First floor
Type - Description: Ceiling mounted presence detector approx. range d=12 m; ApplicableOccurrence: Sensor; PredefinedType: MOVEMENTSENSOR
Type - Pset_ManufacturerTypeInformation - ArticleNumber: S2-111118-002; ModelReference: Ceiling mounted presence detector approx. range d=12 m; Manufacturer: DDS
Material: IFC Building Material
Pset_ElectricalCostData - CostCodeValue: 2-111118-002; ProductCodeValue: XJ2; Location: NOR; ProductCodeName: NS3420; CostCodeName: Eldata Kode; SystemCodeName: NS3451
Pset_DDS - Mounting Height: 2.70 m; Bus Address: 0.0.-; Voltage loss: 100.0%; Manufacturer: DDS; Above Sea Level ref. Bottom: NNUK=6.00 m; Room tekst: Office; Model Number: Dra.no: 2; Project name: OpenBIM; Floor number: Storey: 3; Above Sea Level ref. Center: NN=6.00 m; Voltage: 0V; Product: Ceiling mounted presence detector approx. range d=12 m; Building Part: Building: 0; Product Number: S2-111118-002; Cable length to central: 0.000 m
AC_Pset_RenovationAndPhasing - Renovation Status: Existing
Name | SystemCodeValue = Layer number | Mtg. Below Ceiling ref Top | Mtg. Below Ceiling ref Center | Mtg. above Finished Floor ref Center | Room number | Mtg. Above Slab ref Center | X | Y | Mtg. Above Slab ref Bottom
BuildingControlSystems | 38 | Top= 0.73m FCL | CC= 0.73m FCL | CC= 2.57m FFB | 01.17 | CC= 2.57m SSL | X=8.01 | Y=12.56 | Edge= 2.57m SSL
BuildingControlSystems | 23 | Top= 0.48m FCL | CC= 0.48m FCL | CC= 2.82m FFB | 01.18 | CC= 2.82m SSL | X=10.16 | Y=19.73 | Edge= 2.82m SSL
BuildingControlSystems | 23 | Top= 0.48m FCL | CC= 0.48m FCL | CC= 2.82m FFB | 01.20 | CC= 2.82m SSL | X=14.94 | Y=19.73 | Edge= 2.82m SSL
BuildingControlSystems | 23 | Top= 0.48m FCL | CC= 0.48m FCL | CC= 2.82m FFB | 01.19 | CC= 2.82m SSL | X=19.44 | Y=19.73 | Edge= 2.82m SSL

# IfcEnergyConversionDevice: AH-20111213-041, VAHU
In: 02 Second floor
Type - Description: Ventilation Unit with Heat Exchanger , Extract above 4 x 2 x 2 m; ApplicableOccurrence: Air Handling Units; PredefinedType: AIRHANDLER
Type - Pset_ManufacturerTypeInformation - ArticleNumber: AH-20111213-041; ModelReference: Ventilation Unit with Heat Exchanger , Extract above 4 x 2 x 2 m; Manufacturer: DDS
Material: IFC Building Material; Group: UE; Outdoor air; Extract air; Supply air
Pset_DDS - Y: Y=12.00; Mtg. Above Slab ref Center: CC= -0.13m SSL; Mounting Height: 0.00 m; Mtg. Below Ceiling ref Center: CC= 3.43m FCL; Dimension DN: 2000 mm; Manufacturer: DDS; Room tekst: Installation space; Above Sea Level ref. Center: NN=6.80 m; Model Number: Dra.no: 3; Layer number: 26; Project name: OpenBIM; Above Sea Level ref. Bottom: NNUK=5.80 m; Floor number: Storey: 4; Product: Ventilation Unit with Heat Exchanger , Extract above 4 x 2 x 2 m; Product Number: AH-20111213-041; Mtg. Below Ceiling ref Top: Top= 2.43m FCL; Length: 4000; Width: 2000; Mtg. above Finished Floor ref Center: CC= -0.13m FFB; Room number: 02.04; X: X=18.63; Building Part: Building: 0; Mtg. Above Slab ref Bottom: Edge= -1.13m SSL
AC_Pset_RenovationAndPhasing - Renovation Status: Existing

# IfcEnergyConversionDevice: AH-240913151652, VAHU
In: 03. Roof
Type - Description: Multi V plus II 208-230V; ApplicableOccurrence: Air Handling Units; PredefinedType: AIRHANDLER
Type - Pset_ManufacturerTypeInformation - ArticleNumber: AH-240913151652; ModelReference: Multi V plus II 208-230V; Manufacturer: DDS
Material: IFC Building Material
Pset_DDS - X: X=32.03; Mounting Height: 0.10 m; Above Sea Level ref. Bottom: NNUK=10.13 m; Product: Multi V plus II 208-230V; Mtg. above Finished Floor ref Center: CC= 0.10m FFB; Manufacturer: DDS; Mtg. Above Slab ref Center: CC= 0.10m SSL; Mtg. Below Ceiling ref Center: CC= 3.27m FCL; Above Sea Level ref. Center: NN=10.40 m; Model Number: Dra.no: 4; Dimension DN: 0 mm; Layer number: 26; Mtg. Above Slab ref Bottom: Edge= -0.17m SSL; Project name: OpenBIM; Width: 0; Length: 0; Floor number: Storey: 5; Product Number: AH-240913151652; Y: Y=12.67; Building Part: Building: 0; Mtg. Below Ceiling ref Top: Top= 0.00m FCL
AC_Pset_RenovationAndPhasing - Renovation Status: Existing

# IfcEnergyConversionDevice: GF760 (3)
In: 02 Second floor
Type - Description: Condensing boiler; ApplicableOccurrence: Basic; PredefinedType: WATER
Type - Pset_ManufacturerTypeInformation - ArticleNumber: GF760; ModelReference: Condensing boiler; Manufacturer: DDS
Material: IFC Building Material
Pset_DDS - Mounting Height: 0.60 m; Above Sea Level ref. Center: NN=7.58 m; Product Number: GF760; Dimension DN: 630 mm; X: X=7.98; Manufacturer: DDS; Room tekst: Installation space; Above Sea Level ref. Bottom: NNUK=7.40 m; Model Number: Dra.no: 3; Layer number: 30; Length: 900; Project name: OpenBIM; Floor number: Storey: 4; Mtg. above Finished Floor ref Center: CC= 0.65m FFB; Mtg. Below Ceiling ref Center: CC= 2.65m FCL; Mtg. Below Ceiling ref Top: Top= 2.47m FCL; Product: Condensing boiler; Room number: 02.04; Mtg. Above Slab ref Center: CC= 0.65m SSL; Width: 630; Building Part: Building: 0; Mtg. Above Slab ref Bottom: Edge= 0.47m SSL
AC_Pset_RenovationAndPhasing - Renovation Status: Existing
Name | Y
Boiler/Safety Device | Y=12.88
Boiler/Safety Device | Y=12.25
Boiler/Safety Device | Y=13.51

# IfcEnergyConversionDevice: H1-090610-788, Heating/Cooling Device
In: 01 First floor
Type - Description: Valve Radiator Plan, Typ 10 505/805, Bottom connection to Valve; ApplicableOccurrence: Generic manufacturer equipment; PredefinedType: SECTIONALRADIATOR
Type - Pset_ManufacturerTypeInformation - ArticleNumber: H1-090610-788; ModelReference: Valve Radiator Plan, Typ 10 505/805, Bottom connection to Valve; ModelLabel: H1; Manufacturer: DDS
Type - Pset_SpaceHeaterTypeCommon - OutputCapacity: 360 W
Material: IFC Building Material
Pset_DDS - Pr. drop radiator valve: 0 Pa; Pr. drop lock shield valve: 0 Pa; Total pr. drop: 0 Pa; Pressure drop: 0 Pa; Mtg. Below Ceiling ref Top: Top= 2.55m FCL; ID number: 41; Product: Valve Radiator Plan, Typ 10 505/805, Bottom connection to Valve; Dimensioned: Yes; Mtg. Above Slab ref Bottom: Edge= 0.24m SSL; Manufacturer: DDS; Dimension DN: 505 mm; Above Sea Level ref. Bottom: NNUK=3.42 m; Mounting Height: 0.12 m; Above Sea Level ref. Center: NN=3.67 m; Return temperature: 47 \X\B0C; Mtg. Below Ceiling ref Center: CC= 2.81m FCL; Room number: 01.13; Model Number: Dra.no: 2; Layer number: 10; Height: 505; Length: 805; Width: 805; Mtg. above Finished Floor ref Center: CC= 0.49m FFB; Room tekst: Storage; Surface: 0.94; Project name: OpenBIM; Standard power: 360 W; Floor number: Storey: 3; Y: Y=22.32; Qh: 0 W; Product Number: H1-090610-788; X: X=22.50; Mtg. Above Slab ref Center: CC= 0.49m SSL; KV lock shield valve: 0.0; KV radiator valve: 0.0; Depth: 63; Qh_max: 289 W; Building Part: Building: 0
AC_Pset_RenovationAndPhasing - Renovation Status: Existing

# IfcEnergyConversionDevice: H1-090610-802, Heating/Cooling Device
In: 00 Ground floor
Type - Description: Valve Radiator Plan, Typ 11 505/505, Bottom connection to Valve; ApplicableOccurrence: Generic manufacturer equipment; PredefinedType: SECTIONALRADIATOR
Type - Pset_ManufacturerTypeInformation - ArticleNumber: H1-090610-802; ModelReference: Valve Radiator Plan, Typ 11 505/505, Bottom connection to Valve; ModelLabel: H1; Manufacturer: DDS
Type - Pset_SpaceHeaterTypeCommon - OutputCapacity: 378 W
Material: IFC Building Material
Pset_DDS - X: X=40.80; Pr. drop radiator valve: 0 Pa; Pr. drop lock shield valve: 0 Pa; Total pr. drop: 0 Pa; Pressure drop: 0 Pa; Product: Valve Radiator Plan, Typ 11 505/505, Bottom connection to Valve; Mtg. Below Ceiling ref Top: Top= 2.55m FCL; Y: Y=12.89; Above Sea Level ref. Center: NN=0.17 m; Surface: 2.05; Dimensioned: Yes; Mtg. Above Slab ref Bottom: Edge= 0.24m SSL; Manufacturer: DDS; Dimension DN: 505 mm; Mounting Height: 0.12 m; Mtg. Below Ceiling ref Center: CC= 2.81m FCL; Room number: 00.12; Model Number: Dra.no: 1; Layer number: 10; Width: 505; Length: 505; Height: 505; Mtg. above Finished Floor ref Center: CC= 0.49m FFB; Return temperature: 52 \X\B0C; Room tekst: Storage; Project name: OpenBIM; Floor number: Storey: 2; Product Number: H1-090610-802; Qh_max: 304 W; Qh: 0 W; ID number: 16; Above Sea Level ref. Bottom: NNUK=-0.08 m; Mtg. Above Slab ref Center: CC= 0.49m SSL; Standard power: 378 W; KV lock shield valve: 0.0; KV radiator valve: 0.0; Depth: 63; Building Part: Building: 0
AC_Pset_RenovationAndPhasing - Renovation Status: Existing

# IfcEnergyConversionDevice: H1-090610-807 (2)
In: 01 First floor
Type - Description: Valve Radiator Plan, Typ 11 505/1005, Bottom connection to Valve; ApplicableOccurrence: Generic manufacturer equipment; PredefinedType: SECTIONALRADIATOR
Type - Pset_ManufacturerTypeInformation - ArticleNumber: H1-090610-807; ModelReference: Valve Radiator Plan, Typ 11 505/1005, Bottom connection to Valve; ModelLabel: H1; Manufacturer: DDS
Type - Pset_SpaceHeaterTypeCommon - OutputCapacity: 753 W
Material: IFC Building Material
Pset_DDS - Mtg. Above Slab ref Bottom: Edge= -0.01m SSL; Pr. drop radiator valve: 0 Pa; Pr. drop lock shield valve: 0 Pa; Total pr. drop: 0 Pa; Pressure drop: 0 Pa; Mtg. Below Ceiling ref Center: CC= 3.06m FCL; Surface: 4.08; Product: Valve Radiator Plan, Typ 11 505/1005, Bottom connection to Valve; Dimensioned: Yes; Manufacturer: DDS; Dimension DN: 505 mm; Above Sea Level ref. Bottom: NNUK=3.42 m; Mounting Height: 0.12 m; Above Sea Level ref. Center: NN=3.67 m; Mtg. Below Ceiling ref Top: Top= 2.81m FCL; Room tekst: Office; Room number: 01.17; Return temperature: 50 \X\B0C; Model Number: Dra.no: 2; Layer number: 10; Height: 505; Project name: OpenBIM; Floor number: Storey: 3; Product Number: H1-090610-807; Mtg. Above Slab ref Center: CC= 0.24m SSL; Qh_max: 606 W; Mtg. above Finished Floor ref Center: CC= 0.24m FFB; Qh: 0 W; Standard power: 753 W; KV lock shield valve: 0.0; KV radiator valve: 0.0; Depth: 63; Building Part: Building: 0; Length: 1005; Width: 1005; X: X=5.33
AC_Pset_RenovationAndPhasing - Renovation Status: Existing
Name | Y | ID number
Heating/Cooling Device | Y=11.80 | 43
Heating/Cooling Device | Y=14.00 | 42

# IfcEnergyConversionDevice: H1-090610-809 (9)
In: 00 Ground floor
Type - Description: Valve Radiator Plan, Typ 11 505/1205, Bottom connection to Valve; ApplicableOccurrence: Generic manufacturer equipment; PredefinedType: SECTIONALRADIATOR
Type - Pset_ManufacturerTypeInformation - ArticleNumber: H1-090610-809; ModelReference: Valve Radiator Plan, Typ 11 505/1205, Bottom connection to Valve; ModelLabel: H1; Manufacturer: DDS
Type - Pset_SpaceHeaterTypeCommon - OutputCapacity: 903 W
Material: IFC Building Material
Pset_DDS - Pr. drop radiator valve: 0 Pa; Pr. drop lock shield valve: 0 Pa; Total pr. drop: 0 Pa; Pressure drop: 0 Pa; Mtg. Below Ceiling ref Top: Top= 2.67m FCL; Mtg. Below Ceiling ref Center: CC= 2.93m FCL; Above Sea Level ref. Center: NN=0.17 m; Mtg. Above Slab ref Bottom: Edge= 0.12m SSL; Dimensioned: Yes; Manufacturer: DDS; Dimension DN: 505 mm; Mounting Height: 0.12 m; Mtg. above Finished Floor ref Center: CC= 0.37m FFB; Product: Valve Radiator Plan, Typ 11 505/1205, Bottom connection to Valve; Model Number: Dra.no: 1; Layer number: 10; Height: 505; Project name: OpenBIM; Mtg. Above Slab ref Center: CC= 0.37m SSL; Floor number: Storey: 2; Product Number: H1-090610-809; Standard power: 903 W; Qh: 0 W; Qh_max: 726 W; Surface: 4.89; Above Sea Level ref. Bottom: NNUK=-0.08 m; KV lock shield valve: 0.0; KV radiator valve: 0.0; Depth: 63; Building Part: Building: 0; Width: 1205; Length: 1205
AC_Pset_RenovationAndPhasing - Renovation Status: Existing
Name | Room tekst | Y | Return temperature | ID number | Room number | X
Heating/Cooling Device | Staircase | Y=20.90 | 52 \X\B0C | 15 | 00.05 | X=5.33
Heating/Cooling Device | Office | Y=22.32 | 50 \X\B0C | 23 | 00.20 | X=11.25
Heating/Cooling Device | Office | Y=22.32 | 50 \X\B0C | 24 | 00.20 | X=9.00
Heating/Cooling Device | Office | Y=22.32 | 51 \X\B0C | 25 | 00.21 | X=15.75
Heating/Cooling Device | Office | Y=22.32 | 51 \X\B0C | 26 | 00.21 | X=13.50
Heating/Cooling Device | Storage | Y=22.32 | 51 \X\B0C | 27 | 00.22 | X=22.50
Heating/Cooling Device | Office | Y=22.32 | 51 \X\B0C | 35 | 001 | X=20.25
Heating/Cooling Device | Office | Y=22.32 | 51 \X\B0C | 36 | 001 | X=18.00
Heating/Cooling Device | Staircase | Y=22.32 | 52 \X\B0C | 14 | 00.05 | X=6.75

# IfcEnergyConversionDevice: H1-090610-811, Heating/Cooling Device
In: 00 Ground floor
Type - Description: Valve Radiator Plan, Typ 11 505/1405, Bottom connection to Valve; ApplicableOccurrence: Generic manufacturer equipment; PredefinedType: SECTIONALRADIATOR
Type - Pset_ManufacturerTypeInformation - ArticleNumber: H1-090610-811; ModelReference: Valve Radiator Plan, Typ 11 505/1405, Bottom connection to Valve; ModelLabel: H1; Manufacturer: DDS
Type - Pset_SpaceHeaterTypeCommon - OutputCapacity: 1053 W
Material: IFC Building Material
Pset_DDS - Pr. drop radiator valve: 0 Pa; Pr. drop lock shield valve: 0 Pa; Total pr. drop: 0 Pa; Pressure drop: 0 Pa; Mtg. Below Ceiling ref Top: Top= 2.55m FCL; Surface: 5.70; Above Sea Level ref. Center: NN=0.17 m; ID number: 31; Dimensioned: Yes; Mtg. Above Slab ref Bottom: Edge= 0.24m SSL; Manufacturer: DDS; Dimension DN: 505 mm; Mounting Height: 0.12 m; Mtg. Below Ceiling ref Center: CC= 2.81m FCL; Model Number: Dra.no: 1; Layer number: 10; Qh_max: 847 W; Height: 505; Mtg. above Finished Floor ref Center: CC= 0.49m FFB; Room number: 00.24; Return temperature: 52 \X\B0C; Project name: OpenBIM; Floor number: Storey: 2; Qh: 0 W; Standard power: 1053 W; Product: Valve Radiator Plan, Typ 11 505/1405, Bottom connection to Valve; Length: 1405; Width: 1405; Room tekst: Director office; Above Sea Level ref. Bottom: NNUK=-0.08 m; Mtg. Above Slab ref Center: CC= 0.49m SSL; KV lock shield valve: 0.0; KV radiator valve: 0.0; Depth: 63; Building Part: Building: 0; Y: Y=7.03; X: X=38.97; Product Number: H1-090610-811
AC_Pset_RenovationAndPhasing - Renovation Status: Existing

# IfcEnergyConversionDevice: H1-090610-821 (3)
In: 01 First floor
Type - Description: Valve Radiator Plan, Typ 12 505/705, Bottom connection to Valve; ApplicableOccurrence: Generic manufacturer equipment; PredefinedType: SECTIONALRADIATOR
Type - Pset_ManufacturerTypeInformation - ArticleNumber: H1-090610-821; ModelReference: Valve Radiator Plan, Typ 12 505/705, Bottom connection to Valve; ModelLabel: H1; Manufacturer: DDS
Type - Pset_SpaceHeaterTypeCommon - OutputCapacity: 672 W
Material: IFC Building Material
Pset_DDS - Qh_max: 537 W; Pr. drop radiator valve: 0 Pa; Pr. drop lock shield valve: 0 Pa; Total pr. drop: 0 Pa; Pressure drop: 0 Pa; Mtg. Below Ceiling ref Top: Top= 2.55m FCL; Dimensioned: Yes; Mtg. Above Slab ref Bottom: Edge= 0.24m SSL; Manufacturer: DDS; Dimension DN: 505 mm; Above Sea Level ref. Bottom: NNUK=3.42 m; Mounting Height: 0.12 m; Above Sea Level ref. Center: NN=3.67 m; Product Number: H1-090610-821; Mtg. Below Ceiling ref Center: CC= 2.81m FCL; Room tekst: Office; Surface: 2.97; Model Number: Dra.no: 2; Layer number: 10; Length: 705; Width: 705; Height: 505; Mtg. above Finished Floor ref Center: CC= 0.49m FFB; Project name: OpenBIM; Product: Valve Radiator Plan, Typ 12 505/705, Bottom connection to Valve; Floor number: Storey: 3; Y: Y=22.32; Qh: 0 W; Depth: 66; Mtg. Above Slab ref Center: CC= 0.49m SSL; Standard power: 672 W; KV lock shield valve: 0.0; KV radiator valve: 0.0; Building Part: Building: 0
AC_Pset_RenovationAndPhasing - Renovation Status: Existing
Name | X | Return temperature | ID number | Room number
Heating/Cooling Device | X=15.75 | 52 \X\B0C | 46 | 01.20
Heating/Cooling Device | X=18.00 | 52 \X\B0C | 45 | 01.19
Heating/Cooling Device | X=11.25 | 51 \X\B0C | 44 | 01.18

# IfcEnergyConversionDevice: H1-090610-826 (6)
Type - Description: Valve Radiator Plan, Typ 12 505/1205, Bottom connection to Valve; ApplicableOccurrence: Generic manufacturer equipment; PredefinedType: SECTIONALRADIATOR
Type - Pset_ManufacturerTypeInformation - ArticleNumber: H1-090610-826; ModelReference: Valve Radiator Plan, Typ 12 505/1205, Bottom connection to Valve; ModelLabel: H1; Manufacturer: DDS
Type - Pset_SpaceHeaterTypeCommon - OutputCapacity: 1149 W
Material: IFC Building Material
Pset_DDS - Pr. drop radiator valve: 0 Pa; Pr. drop lock shield valve: 0 Pa; Total pr. drop: 0 Pa; Pressure drop: 0 Pa; Dimensioned: Yes; Manufacturer: DDS; Dimension DN: 505 mm; Mounting Height: 0.12 m; Return temperature: 55 \X\B0C; Product Number: H1-090610-826; Layer number: 10; Height: 505; Product: Valve Radiator Plan, Typ 12 505/1205, Bottom connection to Valve; Project name: OpenBIM; Qh: 0 W; Standard power: 1149 W; Depth: 66; Surface: 5.09; KV lock shield valve: 0.0; KV radiator valve: 0.0; Building Part: Building: 0; Qh_max: 917 W; Width: 1205; Length: 1205
AC_Pset_RenovationAndPhasing - Renovation Status: Existing
Name | In | Mtg. Below Ceiling ref Top | Above Sea Level ref. Center | X | Mtg. Above Slab ref Bottom | Mtg. Below Ceiling ref Center | ID number | Room tekst | Model Number | Mtg. above Finished Floor ref Center | Room number | Floor number | Y | Above Sea Level ref. Bottom | Mtg. Above Slab ref Center
Heating/Cooling Device | 00 Ground floor | Top= 2.55m FCL | NN=0.17 m | X=34.87 | Edge= 0.24m SSL | CC= 2.81m FCL | 28 | Office | Dra.no: 1 | CC= 0.49m FFB | 00.23 | Storey: 2 | Y=22.32 | NNUK=-0.08 m | CC= 0.49m SSL
Heating/Cooling Device | 00 Ground floor | Top= 2.55m FCL | NN=0.17 m | X=37.42 | Edge= 0.24m SSL | CC= 2.81m FCL | 29 | Office | Dra.no: 1 | CC= 0.49m FFB | 00.23 | Storey: 2 | Y=22.32 | NNUK=-0.08 m | CC= 0.49m SSL
Heating/Cooling Device | 00 Ground floor | Top= 2.55m FCL | NN=0.17 m | X=40.80 | Edge= 0.24m SSL | CC= 2.81m FCL | 30 | Office | Dra.no: 1 | CC= 0.49m FFB | 00.23 | Storey: 2 | Y=19.00 | NNUK=-0.08 m | CC= 0.49m SSL
Heating/Cooling Device | 01 First floor | Top= 2.81m FCL | NN=3.67 m | X=29.75 | Edge= -0.01m SSL | CC= 3.06m FCL | 38 | Hallway | Dra.no: 2 | CC= 0.24m FFB | 01.02 | Storey: 3 | Y=22.32 | NNUK=3.42 m | CC= 0.24m SSL
Heating/Cooling Device | 01 First floor | Top= 2.81m FCL | NN=3.67 m | X=27.00 | Edge= -0.01m SSL | CC= 3.06m FCL | 37 | Hallway | Dra.no: 2 | CC= 0.24m FFB | 01.02 | Storey: 3 | Y=22.32 | NNUK=3.42 m | CC= 0.24m SSL
Heating/Cooling Device | 01 First floor | Top= 2.81m FCL | NN=3.67 m | X=24.75 | Edge= -0.01m SSL | CC= 3.06m FCL | 39 | Hallway | Dra.no: 2 | CC= 0.24m FFB | 01.02 | Storey: 3 | Y=22.32 | NNUK=3.42 m | CC= 0.24m SSL

# IfcEnergyConversionDevice: H1-090610-827 (2)
Type - Description: Valve Radiator Plan, Typ 12 505/1305, Bottom connection to Valve; ApplicableOccurrence: Generic manufacturer equipment; PredefinedType: SECTIONALRADIATOR
Type - Pset_ManufacturerTypeInformation - ArticleNumber: H1-090610-827; ModelReference: Valve Radiator Plan, Typ 12 505/1305, Bottom connection to Valve; ModelLabel: H1; Manufacturer: DDS
Type - Pset_SpaceHeaterTypeCommon - OutputCapacity: 1245 W
Material: IFC Building Material
Pset_DDS - Mtg. Above Slab ref Bottom: Edge= -0.01m SSL; Width: 1305; Length: 1305; Pr. drop radiator valve: 0 Pa; Pr. drop lock shield valve: 0 Pa; Total pr. drop: 0 Pa; Pressure drop: 0 Pa; Mtg. Below Ceiling ref Center: CC= 3.06m FCL; Qh_max: 994 W; Dimensioned: Yes; Manufacturer: DDS; Standard power: 1245 W; Dimension DN: 505 mm; Mounting Height: 0.12 m; Product Number: H1-090610-827; Mtg. Below Ceiling ref Top: Top= 2.81m FCL; Layer number: 10; Height: 505; Product: Valve Radiator Plan, Typ 12 505/1305, Bottom connection to Valve; Return temperature: 52 \X\B0C; Project name: OpenBIM; Mtg. Above Slab ref Center: CC= 0.24m SSL; Mtg. above Finished Floor ref Center: CC= 0.24m FFB; Qh: 0 W; Surface: 5.51; Depth: 66; KV lock shield valve: 0.0; KV radiator valve: 0.0; Building Part: Building: 0
AC_Pset_RenovationAndPhasing - Renovation Status: Existing
Name | In | X | Above Sea Level ref. Center | ID number | Model Number | Room number | Floor number | Room tekst | Above Sea Level ref. Bottom | Y
Heating/Cooling Device | 00 Ground floor | X=35.19 | NN=0.17 m | 32 | Dra.no: 1 | 00.25 | Storey: 2 | Director office | NNUK=-0.08 m | Y=7.03
Heating/Cooling Device | 01 First floor | X=6.75 | NN=3.67 m | 40 | Dra.no: 2 | 01.05 | Storey: 3 | Staircase | NNUK=3.42 m | Y=22.32

# IfcEnergyConversionDevice: H1-090610-844, Heating/Cooling Device
In: 00 Ground floor
Type - Description: Valve Radiator Plan, Typ 22 505/1305, Bottom connection to Valve; ApplicableOccurrence: Generic manufacturer equipment; PredefinedType: SECTIONALRADIATOR
Type - Pset_ManufacturerTypeInformation - ArticleNumber: H1-090610-844; ModelReference: Valve Radiator Plan, Typ 22 505/1305, Bottom connection to Valve; ModelLabel: H1; Manufacturer: DDS
Type - Pset_SpaceHeaterTypeCommon - OutputCapacity: 1747 W
Material: IFC Building Material
Pset_DDS - Standard power: 1747 W; Width: 1305; Length: 1305; Pr. drop radiator valve: 0 Pa; Pr. drop lock shield valve: 0 Pa; Total pr. drop: 0 Pa; Pressure drop: 0 Pa; Mtg. Below Ceiling ref Top: Top= 2.67m FCL; Product Number: H1-090610-844; Mtg. Below Ceiling ref Center: CC= 2.93m FCL; Above Sea Level ref. Center: NN=0.17 m; Y: Y=10.63; Mtg. Above Slab ref Bottom: Edge= 0.12m SSL; Dimensioned: Yes; X: X=6.75; Manufacturer: DDS; ID number: 22; Dimension DN: 505 mm; Mounting Height: 0.12 m; Mtg. above Finished Floor ref Center: CC= 0.37m FFB; Room number: 00.19; Room tekst: Office; Model Number: Dra.no: 1; Layer number: 10; Depth: 102; Height: 505; Project name: OpenBIM; Mtg. Above Slab ref Center: CC= 0.37m SSL; Floor number: Storey: 2; Qh: 0 W; Product: Valve Radiator Plan, Typ 22 505/1305, Bottom connection to Valve; Qh_max: 1398 W; Surface: 7.99; Return temperature: 53 \X\B0C; Above Sea Level ref. Bottom: NNUK=-0.08 m; KV lock shield valve: 0.0; KV radiator valve: 0.0; Building Part: Building: 0
AC_Pset_RenovationAndPhasing - Renovation Status: Existing

# IfcEnergyConversionDevice: H1-090610-856 (2)
In: 02 Second floor
Type - Description: Valve Radiator Plan, Typ 33 505/805, Bottom connection to Valve; ApplicableOccurrence: Generic manufacturer equipment; PredefinedType: SECTIONALRADIATOR
Type - Pset_ManufacturerTypeInformation - ArticleNumber: H1-090610-856; ModelReference: Valve Radiator Plan, Typ 33 505/805, Bottom connection to Valve; ModelLabel: H1; Manufacturer: DDS
Type - Pset_SpaceHeaterTypeCommon - OutputCapacity: 1530 W
Material: IFC Building Material
Pset_DDS - Mtg. Above Slab ref Bottom: Edge= -0.01m SSL; Pr. drop radiator valve: 0 Pa; Pr. drop lock shield valve: 0 Pa; Total pr. drop: 0 Pa; Pressure drop: 0 Pa; Mtg. Below Ceiling ref Center: CC= 3.06m FCL; Above Sea Level ref. Center: NN=7.17 m; Dimensioned: Yes; Manufacturer: DDS; Above Sea Level ref. Bottom: NNUK=6.92 m; Dimension DN: 505 mm; Mounting Height: 0.12 m; Standard power: 1530 W; Mtg. Below Ceiling ref Top: Top= 2.81m FCL; Product Number: H1-090610-856; Model Number: Dra.no: 3; Layer number: 10; Height: 505; Length: 805; Width: 805; Project name: OpenBIM; Room tekst: Unnamed; Product: Valve Radiator Plan, Typ 33 505/805, Bottom connection to Valve; Floor number: Storey: 4; Mtg. Above Slab ref Center: CC= 0.24m SSL; Mtg. above Finished Floor ref Center: CC= 0.24m FFB; Qh: 0 W; Depth: 157; Surface: 7.39; Return temperature: 53 \X\B0C; Room number: 02.03; KV lock shield valve: 0.0; KV radiator valve: 0.0; Building Part: Building: 0; Y: Y=19.83; Qh_max: 1227 W
AC_Pset_RenovationAndPhasing - Renovation Status: Existing
Name | X | ID number
Heating/Cooling Device | X=28.12 | 52
Heating/Cooling Device | X=23.62 | 51

# IfcEnergyConversionDevice: H1-090610-861 (3)
In: 00 Ground floor
Type - Description: Valve Radiator Plan, Typ 33 505/1305, Bottom connection to Valve; ApplicableOccurrence: Generic manufacturer equipment; PredefinedType: SECTIONALRADIATOR
Type - Pset_ManufacturerTypeInformation - ArticleNumber: H1-090610-861; ModelReference: Valve Radiator Plan, Typ 33 505/1305, Bottom connection to Valve; ModelLabel: H1; Manufacturer: DDS
Type - Pset_SpaceHeaterTypeCommon - OutputCapacity: 2481 W
Material: IFC Building Material
Pset_DDS - Width: 1305; Length: 1305; Pr. drop radiator valve: 0 Pa; Pr. drop lock shield valve: 0 Pa; Total pr. drop: 0 Pa; Pressure drop: 0 Pa; Mtg. Below Ceiling ref Top: Top= 2.67m FCL; Mtg. Below Ceiling ref Center: CC= 2.93m FCL; Above Sea Level ref. Center: NN=0.17 m; Mtg. Above Slab ref Bottom: Edge= 0.12m SSL; Dimensioned: Yes; Manufacturer: DDS; Dimension DN: 505 mm; Mounting Height: 0.12 m; Mtg. above Finished Floor ref Center: CC= 0.37m FFB; Standard power: 2481 W; Surface: 11.98; Model Number: Dra.no: 1; Layer number: 10; Height: 505; Return temperature: 52 \X\B0C; Project name: OpenBIM; Mtg. Above Slab ref Center: CC= 0.37m SSL; Floor number: Storey: 2; Y: Y=22.32; Room tekst: Hallway; Qh: 0 W; Depth: 157; Room number: 00.03; Product Number: H1-090610-861; Qh_max: 1989 W; Above Sea Level ref. Bottom: NNUK=-0.08 m; KV lock shield valve: 0.0; KV radiator valve: 0.0; Building Part: Building: 0; Product: Valve Radiator Plan, Typ 33 505/1305, Bottom connection to Valve
AC_Pset_RenovationAndPhasing - Renovation Status: Existing
Name | ID number | X
Heating/Cooling Device | 11 | X=29.75
Heating/Cooling Device | 10 | X=27.00
Heating/Cooling Device | 9 | X=24.75

# IfcEnergyConversionDevice: H1-090611-041, Heating/Cooling Device
In: 02 Second floor
Type - Description: Valve Radiator Plan, Typ 12 905/905, Bottom connection to Valve; ApplicableOccurrence: Generic manufacturer equipment; PredefinedType: SECTIONALRADIATOR
Type - Pset_ManufacturerTypeInformation - ArticleNumber: H1-090611-041; ModelReference: Valve Radiator Plan, Typ 12 905/905, Bottom connection to Valve; ModelLabel: H1; Manufacturer: DDS
Type - Pset_SpaceHeaterTypeCommon - OutputCapacity: 1448 W
Material: IFC Building Material
Pset_DDS - Mtg. Above Slab ref Bottom: Edge= -0.01m SSL; Pr. drop radiator valve: 0 Pa; Pr. drop lock shield valve: 0 Pa; Total pr. drop: 0 Pa; Pressure drop: 0 Pa; Product Number: H1-090611-041; Surface: 7.00; Mtg. Below Ceiling ref Center: CC= 2.86m FCL; Dimensioned: Yes; Manufacturer: DDS; Above Sea Level ref. Center: NN=7.37 m; Above Sea Level ref. Bottom: NNUK=6.92 m; Dimension DN: 905 mm; Mounting Height: 0.12 m; ID number: 47; Return temperature: 50 \X\B0C; Model Number: Dra.no: 3; Product: Valve Radiator Plan, Typ 12 905/905, Bottom connection to Valve; Layer number: 10; Height: 905; Width: 905; Length: 905; Project name: OpenBIM; Qh_max: 1154 W; Floor number: Storey: 4; Mtg. Above Slab ref Center: CC= 0.44m SSL; Mtg. above Finished Floor ref Center: CC= 0.44m FFB; Room tekst: Hallway; Qh: 0 W; Mtg. Below Ceiling ref Top: Top= 2.41m FCL; Depth: 66; Y: Y=15.35; X: X=33.40; Room number: 02.01; KV lock shield valve: 0.0; KV radiator valve: 0.0; Standard power: 1448 W; Building Part: Building: 0
AC_Pset_RenovationAndPhasing - Renovation Status: Existing

# IfcFlowController: Flow Control System (2)
Material: IFC Building Material
Pset_DDS - Project name: OpenBIM; Building Part: Building: 0
Pset_FlowControllerCommon - Reference: IFC Building Material
AC_Pset_RenovationAndPhasing - Renovation Status: Existing
Name | In | Mtg. Above Slab ref Center | Mtg. Below Ceiling ref Top | Mtg. Above Slab ref Bottom | Product | Mounting Height | Room tekst | Room number | Mtg. Below Ceiling ref Center | Model Number | Layer number | Above Sea Level ref. Center | Floor number | Y | X | Mtg. above Finished Floor ref Center | Above Sea Level ref. Bottom
MB01 | 00 Ground floor | CC= 0.72m SSL | Top= 2.58m FCL | Edge= 0.72m SSL | Unit for kWh meter and fuse units 3 RU 1.100x800x205 mm | 0.85 m | FB | 00.15 | CC= 2.58m FCL | Dra.no: 1 | 5 | NN=0.65 m | Storey: 2 | Y=10.29 | X=29.26 | CC= 0.72m FFB | NNUK=0.65 m | Description: Main distribution board 1; Pset_DDS - Switchboard Text: MB01; Depth Text: 0.20; Width Text: 0.80; Height Text: 1.10; Manufacturer: DDS; Product Number: SB-030916-008; Switchboard Extra Text: Main distribution board 1; Pset_ElectricalCostData - ProductCodeValue: WD2; Location: NOR; ProductCodeName: NS3420; SystemCodeValue: 5; CostCodeValue: B-030916-008; CostCodeName: Eldata Kode; SystemCodeName: NS3451
Di2901 | 02 Second floor | CC= -0.53m SSL | Top= 3.83m FCL | Edge= -0.53m SSL | No product matches criteria | -0.40 m | Installation space | 02.04 | CC= 3.83m FCL | Dra.no: 3 | 17 | NN=6.40 m | Storey: 4 | Y=14.49 | X=8.29 | CC= -0.53m FFB | NNUK=6.40 m

# IfcFlowController: S1-030918-001, Switch
In: 00 Ground floor
Type - Description: Flush mounted switch single pole; ApplicableOccurrence: Flush mounted switches; PredefinedType: TOGGLESWITCH
Type - Pset_ManufacturerTypeInformation - ArticleNumber: S1-030918-001; ModelReference: Flush mounted switch single pole; Manufacturer: DDS
Type - Pset_SwitchingDeviceTypeCommon - NumberOfGangs: 1; HasLock: no
Type - Pset_SwitchingDeviceTypeToggleSwitch - IsIlluminated: no; Legend: Allround
Type - Pset_ElectricalDeviceCommon - NumberOfPoles: 1; HasProtectiveEarth: no
Material: IFC Building Material
Pset_DDS - Above Sea Level ref. Bottom: NNUK=0.85 m; Mtg. Below Ceiling ref Center: CC= 2.13m FCL; Voltage loss: 100.0%; Manufacturer: DDS; Above Sea Level ref. Center: NN=0.85 m; Y: Y=19.60; Mounting Height: 1.05 m; Mtg. above Finished Floor ref Center: CC= 1.17m FFB; Room tekst: Office; X: X=33.55; Model Number: Dra.no: 1; Layer number: 7; Room number: 00.23; Project name: OpenBIM; Number of Poles: 1; Mtg. Above Slab ref Center: CC= 1.17m SSL; Floor number: Storey: 2; Power tekst: 16.00; Voltage: 0V; Product Number: S1-030918-001; Mtg. Below Ceiling ref Top: Top= 2.13m FCL; Building Part: Building: 0; Mtg. Above Slab ref Bottom: Edge= 1.17m SSL; Cable length to central: 0.000 m; Product: Flush mounted switch single pole
Pset_ElectricalCostData - CostCodeValue: 1-030918-001; ProductCodeValue: WF2.1; Location: NOR; ProductCodeName: NS3420; SystemCodeValue: 7; CostCodeName: Eldata Kode; SystemCodeName: NS3451
AC_Pset_RenovationAndPhasing - Renovation Status: Existing

# IfcFlowController: TA322/05 (2)
In: 00 Ground floor
Type - Description: Gate valvered white PN 20 3/4 with conical seal; ApplicableOccurrence: Shutoff devices
Type - Pset_ManufacturerTypeInformation - ArticleNumber: TA322/05; ModelReference: Gate valvered white PN 20 3/4 with conical seal; Manufacturer: DDS
Material: IFC Building Material; Group: Coldwater
Pset_DDS - Product Number: TA322/05; Mounting Height: 0.50 m; Pipe thickness:: x1.0; Above Sea Level ref. Center: NN=0.30 m; Dimension DN: 20 mm; Length: 75.0 m; Mtg. Below Ceiling ref Center: CC= 2.93m FCL; Y: Y=10.62; Flow (l/h): 6731.999856 l/h; Main string number: 01; Manufacturer: DDS; Ins thickness: ins= 9.000000 mm; Room tekst: FB; Mtg. above Finished Floor ref Center: CC= 0.37m FFB; System Name: PW; Room number: 00.15; Model Number: Dra.no: 1; Mtg. Above Slab ref Bottom: Edge= 0.36m SSL; Layer number: 2; Width: 20; Project name: OpenBIM; Height: 0; Insulation WSVO: 0; Insulation k-value: 0; Outside dimension: 22.000000; Mtg. Above Slab ref Center: CC= 0.37m SSL; Flow (m\X\B3/h): 6.7 m\X\B3/h; Floor number: Storey: 2; Velocity: 2.31 m/s; Mtg. Below Ceiling ref Top: Top= 2.92m FCL; Pressure drop: 106751; Insulation product text: Pipe insulation; Sub string number: .0001; Flow (l/s): 1.87 l/s; Above Sea Level ref. Bottom: NNUK=0.28 m; Rotation: 0.000000; Building Part: Building: 0; Medium: Coldwater; Product: Gate valvered white PN 20 3/4 with conical seal; Abs. pressure: 351157.7 Pa; Insulation product number: ZP150/922
AC_Pset_RenovationAndPhasing - Renovation Status: Existing
Name | Part number | X
1.1.29 | .029 | X=29.84 | Pset_DDS - Valve adjustment: \X\B7G\X\1A
1.1.31 | .031 | X=29.50

# IfcFlowController: TA322/06 (2)
In: 00 Ground floor
Type - Description: Gate valvered white PN 20 1 with conical seal; ApplicableOccurrence: Shutoff devices
Type - Pset_ManufacturerTypeInformation - ArticleNumber: TA322/06; ModelReference: Gate valvered white PN 20 1 with conical seal; Manufacturer: DDS
Material: IFC Building Material
Pset_DDS - Mounting Height: 0.50 m; Above Sea Level ref. Center: NN=0.30 m; Mtg. Below Ceiling ref Center: CC= 2.93m FCL; Product Number: TA322/06; Y: Y=10.62; Manufacturer: DDS; Ins thickness: ins= 0.000000 mm; Room tekst: FB; Mtg. above Finished Floor ref Center: CC= 0.37m FFB; Outside dimension: 28.000000; Room number: 00.15; Model Number: Dra.no: 1; Mtg. Above Slab ref Bottom: Edge= 0.36m SSL; Layer number: 198; Main string number: 00; Project name: OpenBIM; Height: 0; Insulation WSVO: 0; Insulation k-value: 0; Pressure drop: 0; Mtg. Above Slab ref Center: CC= 0.37m SSL; Flow (m\X\B3/h): 0.0 m\X\B3/h; Floor number: Storey: 2; Width: 25; Medium: Gas middle pressure; Flow (l/h): 0.000000 l/h; Mtg. Below Ceiling ref Top: Top= 2.92m FCL; Length: 90.0 m; Part number: .000; Sub string number: .0000; Above Sea Level ref. Bottom: NNUK=0.28 m; Rotation: 0.000000; Dimension DN: 25 mm; Building Part: Building: 0; Flow (l/s): 0.00 l/s; Pipe thickness:: x1.5; Abs. pressure: 0.0 Pa; Product: Gate valvered white PN 20 1 with conical seal; Velocity: 0.00 m/s
AC_Pset_RenovationAndPhasing - Renovation Status: Existing
Name | X
Valve | X=30.80
Valve | X=30.36

# IfcFlowFitting: BE100090BoL, 1.23.4
In: 00 Ground floor
Type - Description: Rectangular Duct Bend; PredefinedType: BEND
Type - Pset_ManufacturerTypeInformation - ArticleNumber: BE100090BoL; ModelReference: Rectangular Duct Bend; Manufacturer: DDS; ModelLabel: BE
Type - Pset_DuctFittingTypeCommon - NominalDiameterOrWidth: 400; NominalHeight: 300
Material: IFC Building Material; Group: Supply air
Pset_DDS - Mounting Height: 3.00 m; Above Sea Level ref. Center: NN=2.80 m; Flow (l/s): 236.11 l/s; Product: Rectangular Duct Bend; Mtg. Below Ceiling ref Center: CC= 0.43m FCL; Mtg. Above Slab ref Bottom: Edge= 2.72m SSL; Main string number: 01; Manufacturer: DDS; Ins thickness: ins= 0.000000 mm; Part number: .004; Mtg. Below Ceiling ref Top: Top= 0.28m FCL; Mtg. above Finished Floor ref Center: CC= 2.87m FFB; System Name: Supply Air; Medium: Supply Air; Pipe thickness:: x1.1; Flow (l/h): 850000.000000 l/h; Length: 160.0 m; Product Number: BE100090BoL; Model Number: Dra.no: 1; Layer number: 10; Height: 300; Width: 400; Sub string number: .0023; Room number: 00.25; Flow (m\X\B3/h): 850.0 m\X\B3/h; Project name: OpenBIM; Insulation k-value: 0; Pressure drop: 0; Insulation WSVO: 0; Mtg. Above Slab ref Center: CC= 2.87m SSL; Floor number: Storey: 2; X: X=32.36; Abs. pressure: 268.3 Pa; Outside dimension: 400.000000; Dimension DN: 400 x 300 mm; Above Sea Level ref. Bottom: NNUK=2.50 m; Velocity: 1.27 m/s; Room tekst: Director office; Y: Y=8.14; Rotation: 0.000000; Building Part: Building: 0
AC_Pset_RenovationAndPhasing - Renovation Status: Existing

# IfcFlowFitting: BE100090BoL (6)
Type - Description: Rectangular Duct Bend; PredefinedType: BEND
Type - Pset_ManufacturerTypeInformation - ArticleNumber: BE100090BoL; ModelReference: Rectangular Duct Bend; Manufacturer: DDS; ModelLabel: BE
Type - Pset_DuctFittingTypeCommon - NominalDiameterOrWidth: 600; NominalHeight: 300
Material: IFC Building Material
Pset_DDS - Mounting Height: 3.00 m; Product: Rectangular Duct Bend; Manufacturer: DDS; Ins thickness: ins= 0.000000 mm; Pipe thickness:: x1.1; Length: 160.0 m; Product Number: BE100090BoL; Height: 300; Width: 600; Project name: OpenBIM; Insulation k-value: 0; Pressure drop: 0; Insulation WSVO: 0; Outside dimension: 600.000000; Room tekst: Hallway; Dimension DN: 600 x 300 mm; Building Part: Building: 0
AC_Pset_RenovationAndPhasing - Renovation Status: Existing
Name | In | Mtg. Below Ceiling ref Center | Y | Room number | Flow (m\X\B3/h) | Velocity | Rotation | Mtg. Above Slab ref Bottom | Main string number | Sub string number | Abs. pressure | Above Sea Level ref. Bottom | Mtg. Below Ceiling ref Top | Mtg. above Finished Floor ref Center | Above Sea Level ref. Center | Medium | X | Model Number | Part number | Layer number | Mtg. Above Slab ref Center | Floor number | Flow (l/h) | Flow (l/s)
1.34.2 | 01 First floor | CC= 0.43m FCL | Y=12.83 | 01.02 | 1400.0 m\X\B3/h | 2.16 m/s | 180.000000 | Edge= 2.72m SSL | 01 | .0034 | 291.0 Pa | NNUK=6.00 m | Top= 0.28m FCL | CC= 2.87m FFB | NN=6.30 m | Supply Air | X=32.95 | Dra.no: 2 | .002 | 10 | CC= 2.87m SSL | Storey: 3 | 1400000.000000 l/h | 388.89 l/s | Pset_DDS - System Name: Supply Air; Group: Supply air
1.34.6 | 01 First floor | CC= 0.43m FCL | Y=18.31 | 01.02 | 1400.0 m\X\B3/h | 2.16 m/s | 180.000000 | Edge= 2.72m SSL | 01 | .0034 | 287.5 Pa | NNUK=6.00 m | Top= 0.28m FCL | CC= 2.87m FFB | NN=6.30 m | Supply Air | X=32.95 | Dra.no: 2 | .006 | 10 | CC= 2.87m SSL | Storey: 3 | 1400000.000000 l/h | 388.89 l/s | Pset_DDS - System Name: Supply Air; Group: Supply air
Bend | 00 Ground floor | CC= 0.30m FCL | Y=17.04 | 00.03 | 0.0 m\X\B3/h | 0.00 m/s | 180.000000 | Edge= 2.85m SSL | 00 | .0019 | 0.0 Pa | NNUK=2.50 m | Top= 0.15m FCL | CC= 3.00m FFB | NN=2.80 m | Extract Air | X=31.70 | Dra.no: 1 | .000 | 11 | CC= 3.00m SSL | Storey: 2 | 0.000000 l/h | 0.00 l/s
Bend | 00 Ground floor | CC= 0.30m FCL | Y=13.73 | 00.03 | 0.0 m\X\B3/h | 0.00 m/s | 180.000000 | Edge= 2.85m SSL | 00 | .0019 | 0.0 Pa | NNUK=2.50 m | Top= 0.15m FCL | CC= 3.00m FFB | NN=2.80 m | Extract Air | X=31.70 | Dra.no: 1 | .000 | 11 | CC= 3.00m SSL | Storey: 2 | 0.000000 l/h | 0.00 l/s
Bend | 00 Ground floor | CC= 0.30m FCL | Y=15.71 | 00.03 | 0.0 m\X\B3/h | 0.00 m/s | 0.000000 | Edge= 2.85m SSL | 00 | .0019 | 0.0 Pa | NNUK=2.50 m | Top= 0.15m FCL | CC= 3.00m FFB | NN=2.80 m | Extract Air | X=25.24 | Dra.no: 1 | .000 | 11 | CC= 3.00m SSL | Storey: 2 | 0.000000 l/h | 0.00 l/s
Bend | 00 Ground floor | CC= 0.30m FCL | Y=17.04 | 00.03 | 0.0 m\X\B3/h | 0.00 m/s | 180.000000 | Edge= 2.85m SSL | 00 | .0019 | 0.0 Pa | NNUK=2.50 m | Top= 0.15m FCL | CC= 3.00m FFB | NN=2.80 m | Extract Air | X=25.24 | Dra.no: 1 | .000 | 11 | CC= 3.00m SSL | Storey: 2 | 0.000000 l/h | 0.00 l/s

# IfcFlowFitting: BE100090BoL (16)
Type - Description: Rectangular Duct Bend; PredefinedType: BEND
Type - Pset_ManufacturerTypeInformation - ArticleNumber: BE100090BoL; ModelReference: Rectangular Duct Bend; Manufacturer: DDS; ModelLabel: BE
Type - Pset_DuctFittingTypeCommon - NominalDiameterOrWidth: 600; NominalHeight: 600
Material: IFC Building Material
Pset_DDS - Product: Rectangular Duct Bend; Manufacturer: DDS; Ins thickness: ins= 0.000000 mm; Pipe thickness:: x1.1; Product Number: BE100090BoL; Width: 600; Height: 600; Project name: OpenBIM; Insulation k-value: 0; Pressure drop: 0; Insulation WSVO: 0; Outside dimension: 600.000000; Dimension DN: 600 x 600 mm; Building Part: Building: 0
AC_Pset_RenovationAndPhasing - Renovation Status: Existing
Name | In | Mounting Height | Above Sea Level ref. Center | Y | Mtg. Below Ceiling ref Center | X | Main string number | Mtg. above Finished Floor ref Center | Rotation | Flow (m\X\B3/h) | Mtg. Above Slab ref Center | Part number | Medium | Length | Model Number | Layer number | Abs. pressure | Floor number | Sub string number | Flow (l/h) | Velocity | Flow (l/s) | Mtg. Above Slab ref Bottom | Above Sea Level ref. Bottom | Mtg. Below Ceiling ref Top | Room tekst | Room number
1.2.4 | 00 Ground floor | 3.00 m | NN=2.80 m | Y=12.83 | CC= 0.50m FCL | X=30.60 | 01 | CC= 3.00m FFB | 270.000000 | 3482.0 m\X\B3/h | CC= 3.00m SSL | .004 | Supply Air | 600.1 m | Dra.no: 1 | 10 | 283.4 Pa | Storey: 2 | .0002 | 3482000.000000 l/h | 5.37 m/s | 967.22 l/s | Edge= 2.70m SSL | NNUK=2.20 m | Top= 0.00m FCL | Pset_DDS - System Name: Supply Air; Group: Supply air
1.1.10 | 02 Second floor | 2.90 m | NN=9.70 m | Y=12.83 | CC= 0.53m FCL | X=20.97 | 01 | CC= 2.77m FFB | 0.000000 | 4882.0 m\X\B3/h | CC= 2.77m SSL | .010 | Supply Air | 160.0 m | Dra.no: 3 | 10 | 313.2 Pa | Storey: 4 | .0001 | 4882000.000000 l/h | 3.77 m/s | 1356.11 l/s | Edge= 2.47m SSL | NNUK=9.10 m | Top= 0.23m FCL | Installation space | 02.04 | Pset_DDS - System Name: Supply Air; Group: Supply air
1.1.16 | 02 Second floor | 2.90 m | NN=9.70 m | Y=12.83 | CC= 0.40m FCL | X=30.60 | 01 | CC= 2.90m FFB | 90.000000 | 4882.0 m\X\B3/h | CC= 2.90m SSL | .016 | Supply Air | 200.0 m | Dra.no: 3 | 10 | 302.2 Pa | Storey: 4 | .0001 | 4882000.000000 l/h | 3.77 m/s | 1356.11 l/s | Edge= 2.60m SSL | NNUK=9.10 m | Top= 0.00m FCL | Pset_DDS - System Name: Supply Air; Group: Supply air
1.1.2 | 02 Second floor | 0.50 m | NN=7.30 m | Y=11.54 | CC= 2.93m FCL | X=17.63 | 01 | CC= 0.37m FFB | 180.000000 | 4882.0 m\X\B3/h | CC= 0.37m SSL | .002 | Supply Air | 160.0 m | Dra.no: 3 | 10 | 348.1 Pa | Storey: 4 | .0001 | 4882000.000000 l/h | 3.77 m/s | 1356.11 l/s | Edge= 0.07m SSL | NNUK=6.70 m | Top= 2.63m FCL | Installation space | 02.04 | Pset_DDS - System Name: Supply Air; Group: Supply air
1.1.4 | 02 Second floor | 0.50 m | NN=7.30 m | Y=11.54 | CC= 2.93m FCL | X=19.68 | 01 | CC= 0.37m FFB | 180.000000 | 4882.0 m\X\B3/h | CC= 0.37m SSL | .004 | Supply Air | 160.0 m | Dra.no: 3 | 10 | 339.3 Pa | Storey: 4 | .0001 | 4882000.000000 l/h | 3.77 m/s | 1356.11 l/s | Edge= 0.07m SSL | NNUK=6.70 m | Top= 2.63m FCL | Installation space | 02.04 | Pset_DDS - System Name: Supply Air; Group: Supply air
1.1.6 | 02 Second floor | 0.50 m | NN=7.30 m | Y=11.90 | CC= 2.93m FCL | X=20.04 | 01 | CC= 0.37m FFB | 270.000000 | 4882.0 m\X\B3/h | CC= 0.37m SSL | .006 | Supply Air | 160.0 m | Dra.no: 3 | 10 | 330.8 Pa | Storey: 4 | .0001 | 4882000.000000 l/h | 3.77 m/s | 1356.11 l/s | Edge= 0.07m SSL | NNUK=6.70 m | Top= 2.63m FCL | Installation space | 02.04 | Pset_DDS - System Name: Supply Air; Group: Supply air
1.1.8 | 02 Second floor | 2.90 m | NN=9.70 m | Y=11.90 | CC= 0.53m FCL | X=20.04 | 01 | CC= 2.77m FFB | 90.000000 | 4882.0 m\X\B3/h | CC= 2.77m SSL | .008 | Supply Air | 160.0 m | Dra.no: 3 | 10 | 321.9 Pa | Storey: 4 | .0001 | 4882000.000000 l/h | 3.77 m/s | 1356.11 l/s | Edge= 2.47m SSL | NNUK=9.10 m | Top= 0.23m FCL | Installation space | 02.04 | Pset_DDS - System Name: Supply Air; Group: Supply air
Bend | 00 Ground floor | 3.00 m | NN=2.80 m | Y=13.73 | CC= 0.50m FCL | X=30.60 | 00 | CC= 3.00m FFB | 270.000000 | 0.0 m\X\B3/h | CC= 3.00m SSL | .000 | Extract Air | 600.1 m | Dra.no: 1 | 11 | 0.0 Pa | Storey: 2 | .0019 | 0.000000 l/h | 0.00 m/s | 0.00 l/s | Edge= 2.70m SSL | NNUK=2.20 m | Top= 0.00m FCL
Bend | 02 Second floor | 0.50 m | NN=7.30 m | Y=17.16 | CC= 2.93m FCL | X=17.63 | 00 | CC= 0.37m FFB | 270.000000 | 0.0 m\X\B3/h | CC= 0.37m SSL | .000 | Outdoor Air | 160.0 m | Dra.no: 3 | 13 | 0.0 Pa | Storey: 4 | .0000 | 0.000000 l/h | 0.00 m/s | 0.00 l/s | Edge= 0.07m SSL | NNUK=6.70 m | Top= 2.63m FCL | Installation space | 02.04
Bend | 02 Second floor | 2.90 m | NN=9.70 m | Y=12.63 | CC= 0.53m FCL | X=19.18 | 00 | CC= 2.77m FFB | 90.000000 | 0.0 m\X\B3/h | CC= 2.77m SSL | .000 | Extract Air | 160.0 m | Dra.no: 3 | 11 | 0.0 Pa | Storey: 4 | .0000 | 0.000000 l/h | 0.00 m/s | 0.00 l/s | Edge= 2.47m SSL | NNUK=9.10 m | Top= 0.23m FCL | Installation space | 02.04
Bend | 02 Second floor | 1.50 m | NN=8.30 m | Y=16.46 | CC= 1.93m FCL | X=17.63 | 00 | CC= 1.37m FFB | 270.000000 | 0.0 m\X\B3/h | CC= 1.37m SSL | .000 | Exhaust air | 160.0 m | Dra.no: 3 | 14 | 0.0 Pa | Storey: 4 | .0000 | 0.000000 l/h | 0.00 m/s | 0.00 l/s | Edge= 1.07m SSL | NNUK=7.70 m | Top= 1.63m FCL | Installation space | 02.04
Bend | 02 Second floor | 1.50 m | NN=8.30 m | Y=12.63 | CC= 1.93m FCL | X=19.18 | 00 | CC= 1.37m FFB | 270.000000 | 0.0 m\X\B3/h | CC= 1.37m SSL | .000 | Extract Air | 160.0 m | Dra.no: 3 | 11 | 0.0 Pa | Storey: 4 | .0000 | 0.000000 l/h | 0.00 m/s | 0.00 l/s | Edge= 1.07m SSL | NNUK=7.70 m | Top= 1.63m FCL | Installation space | 02.04
Bend | 02 Second floor | 1.50 m | NN=8.30 m | Y=11.54 | CC= 1.93m FCL | X=19.18 | 00 | CC= 1.37m FFB | 180.000000 | 0.0 m\X\B3/h | CC= 1.37m SSL | .000 | Extract Air | 160.0 m | Dra.no: 3 | 11 | 0.0 Pa | Storey: 4 | .0000 | 0.000000 l/h | 0.00 m/s | 0.00 l/s | Edge= 1.07m SSL | NNUK=7.70 m | Top= 1.63m FCL | Installation space | 02.04
Bend | 02 Second floor | 2.90 m | NN=9.70 m | Y=13.73 | CC= 0.40m FCL | X=30.60 | 00 | CC= 2.90m FFB | 90.000000 | 0.0 m\X\B3/h | CC= 2.90m SSL | .000 | Extract Air | 160.0 m | Dra.no: 3 | 11 | 0.0 Pa | Storey: 4 | .0000 | 0.000000 l/h | 0.00 m/s | 0.00 l/s | Edge= 2.60m SSL | NNUK=9.10 m | Top= 0.00m FCL
Bend | 02 Second floor | 1.50 m | NN=8.30 m | Y=11.54 | CC= 1.93m FCL | X=17.63 | 00 | CC= 1.37m FFB | 180.000000 | 0.0 m\X\B3/h | CC= 1.37m SSL | .000 | Extract Air | 160.0 m | Dra.no: 3 | 11 | 0.0 Pa | Storey: 4 | .0000 | 0.000000 l/h | 0.00 m/s | 0.00 l/s | Edge= 1.07m SSL | NNUK=7.70 m | Top= 1.63m FCL | Installation space | 02.04
Bend | 02 Second floor | 2.90 m | NN=9.70 m | Y=13.73 | CC= 0.53m FCL | X=19.18 | 00 | CC= 2.77m FFB | 0.000000 | 0.0 m\X\B3/h | CC= 2.77m SSL | .000 | Extract Air | 160.0 m | Dra.no: 3 | 11 | 0.0 Pa | Storey: 4 | .0000 | 0.000000 l/h | 0.00 m/s | 0.00 l/s | Edge= 2.47m SSL | NNUK=9.10 m | Top= 0.23m FCL | Installation space | 02.04

# IfcFlowFitting: BE3000015045, 3.2.5
In: 00 Ground floor
Type - Description: Cu fitting bend 45\X\B0 15x1 mm; ApplicableOccurrence: Basic; PredefinedType: BEND
Type - Pset_ManufacturerTypeInformation - ArticleNumber: BE3000015045; ModelReference: Cu fitting bend 45\X\B0 15x1 mm; Manufacturer: DDS
Type - Pset_PipeFittingTypeCommon - SubType: Bend 45 degree; NominalDiameter: 12; InnerDiameter: 13; OuterDiameter: 15
Material: IFC Building Material; Group: Circulation
Pset_DDS - Rotation: 90.000000; Flow (l/s): 0.04 l/s; Velocity: 0.32 m/s; Pipe thickness:: x1.0; Length: 45.0 m; Above Sea Level ref. Center: NN=3.05 m; Above Sea Level ref. Bottom: NNUK=3.04 m; Product: Cu fitting bend 45\X\B0 15x1 mm; Mtg. Above Slab ref Bottom: Edge= 3.24m SSL; Manufacturer: DDS; Insulation product text: Pipe insulation; Width: 12; Ins thickness: ins= 9.000000 mm; Mounting Height: 3.25 m; Insulation product number: ZP150/915; X: X=23.03; Room tekst: wc; Abs. pressure: 2413.1 Pa; Flow (l/h): 151.334382 l/h; Y: Y=15.07; Dimension DN: 12 mm; Model Number: Dra.no: 1; Layer number: 4; Project name: OpenBIM; Product Number: BE3000015045; Height: 0; Insulation k-value: 0; Insulation WSVO: 0; Flow (m\X\B3/h): 0.2 m\X\B3/h; Floor number: Storey: 2; Mtg. above Finished Floor ref Center: CC= 3.25m FFB; Mtg. Below Ceiling ref Center: CC= 0.05m FCL; Medium: Circulation; Outside dimension: 15.000000; Sub string number: .0002; Room number: 00.09; Mtg. Above Slab ref Center: CC= 3.25m SSL; Main string number: 03; Building Part: Building: 0; Part number: .005; Mtg. Below Ceiling ref Top: Top= 0.04m FCL; Pressure drop: 2413
AC_Pset_RenovationAndPhasing - Renovation Status: Existing

# IfcFlowFitting: BE3000015090 (106)
Type - Description: Cu fitting bend 90\X\B0 15x1 mm; ApplicableOccurrence: Basic; PredefinedType: BEND
Type - Pset_ManufacturerTypeInformation - ArticleNumber: BE3000015090; ModelReference: Cu fitting bend 90\X\B0 15x1 mm; Manufacturer: DDS
Type - Pset_PipeFittingTypeCommon - SubType: Bend 90 degree; NominalDiameter: 12; InnerDiameter: 13; OuterDiameter: 15
Material: IFC Building Material
Pset_DDS - Pipe thickness:: x1.0; Manufacturer: DDS; Width: 12; Dimension DN: 12 mm; Product Number: BE3000015090; Project name: OpenBIM; Height: 0; Insulation k-value: 0; Insulation WSVO: 0; Length: 90.0 m; Outside dimension: 15.000000; Building Part: Building: 0; Product: Cu fitting bend 90\X\B0 15x1 mm
AC_Pset_RenovationAndPhasing - Renovation Status: Existing
Name | In | Abs. pressure | Mounting Height | Velocity | Mtg. Below Ceiling ref Center | Main string number | Above Sea Level ref. Bottom | Mtg. above Finished Floor ref Center | Insulation product text | Ins thickness | Mtg. Above Slab ref Center | Insulation product number | Part number | Y | System Name | Model Number | Layer number | Sub string number | Flow (l/s) | Flow (l/h) | Flow (m\X\B3/h) | Floor number | Mtg. Above Slab ref Bottom | Above Sea Level ref. Center | Room tekst | Room number | Rotation | Pressure drop | Mtg. Below Ceiling ref Top | Medium | X | Group
1.25.1 | 00 Ground floor | 113847.8 Pa | 3.10 m | 2.24 m/s | CC= 0.40m FCL | 01 | NNUK=2.89 m | CC= 3.10m FFB | Pipe insulation | ins= 9.000000 mm | CC= 3.10m SSL | ZP150/915 | .001 | Y=10.94 | PW | Dra.no: 1 | 2 | .0025 | 0.39 l/s | 1403.999949 l/h | 1.4 m\X\B3/h | Storey: 2 | Edge= 3.09m SSL | NN=2.90 m | Entrance | 00.01 | 0.000000 | 25583 | Top= 0.39m FCL | Coldwater | X=18.90 | Coldwater
1.27.1 | 00 Ground floor | 84629.4 Pa | 3.10 m | 0.98 m/s | CC= 0.20m FCL | 01 | NNUK=2.89 m | CC= 3.10m FFB | Pipe insulation | ins= 9.000000 mm | CC= 3.10m SSL | ZP150/915 | .001 | Y=14.37 | PW | Dra.no: 1 | 2 | .0027 | 0.13 l/s | 467.999983 l/h | 0.5 m\X\B3/h | Storey: 2 | Edge= 3.09m SSL | NN=2.90 m | wc | 00.07 | 179.999998 | 84629 | Top= 0.19m FCL | Coldwater | X=18.90 | Coldwater
1.27.2 | 00 Ground floor | 84629.4 Pa | 0.75 m | 0.98 m/s | CC= 2.74m FCL | 01 | NNUK=0.54 m | CC= 0.75m FFB | Pipe insulation | ins= 9.000000 mm | CC= 0.75m SSL | ZP150/915 | .002 | Y=14.37 | PW | Dra.no: 1 | 2 | .0027 | 0.13 l/s | 467.999983 l/h | 0.5 m\X\B3/h | Storey: 2 | Edge= 0.75m SSL | NN=0.56 m |  |  | 180.000000 | 84629 | Top= 0.00m FCL | Coldwater | X=18.73 | Coldwater
1.27.3 | 00 Ground floor | 84629.4 Pa | 0.75 m | 0.98 m/s | CC= 2.54m FCL | 01 | NNUK=0.54 m | CC= 0.75m FFB | Pipe insulation | ins= 9.000000 mm | CC= 0.75m SSL | ZP150/915 | .003 | Y=14.37 | PW | Dra.no: 1 | 2 | .0027 | 0.13 l/s | 467.999983 l/h | 0.5 m\X\B3/h | Storey: 2 | Edge= 0.75m SSL | NN=0.56 m | wc | 00.07 | 270.000000 | 84629 | Top= 2.54m FCL | Coldwater | X=18.78 | Coldwater
1.27.4 | 00 Ground floor | 84629.4 Pa | 3.10 m | 0.98 m/s | CC= 0.20m FCL | 01 | NNUK=2.89 m | CC= 3.10m FFB | Pipe insulation | ins= 9.000000 mm | CC= 3.10m SSL | ZP150/915 | .004 | Y=14.37 | PW | Dra.no: 1 | 2 | .0027 | 0.13 l/s | 467.999983 l/h | 0.5 m\X\B3/h | Storey: 2 | Edge= 3.09m SSL | NN=2.90 m | wc | 00.07 | 90.000000 | 84629 | Top= 0.19m FCL | Coldwater | X=18.78 | Coldwater
1.28.2 | 00 Ground floor | 83283.5 Pa | 0.75 m | 0.98 m/s | CC= 2.74m FCL | 01 | NNUK=0.54 m | CC= 0.75m FFB | Pipe insulation | ins= 9.000000 mm | CC= 0.75m SSL | ZP150/915 | .002 | Y=13.29 | PW | Dra.no: 1 | 2 | .0028 | 0.13 l/s | 467.999983 l/h | 0.5 m\X\B3/h | Storey: 2 | Edge= 0.75m SSL | NN=0.56 m |  |  | 180.000000 | 83283 | Top= 0.00m FCL | Coldwater | X=18.73 | Coldwater
1.28.3 | 00 Ground floor | 83283.5 Pa | 0.75 m | 0.98 m/s | CC= 2.54m FCL | 01 | NNUK=0.54 m | CC= 0.75m FFB | Pipe insulation | ins= 9.000000 mm | CC= 0.75m SSL | ZP150/915 | .003 | Y=13.29 | PW | Dra.no: 1 | 2 | .0028 | 0.13 l/s | 467.999983 l/h | 0.5 m\X\B3/h | Storey: 2 | Edge= 0.75m SSL | NN=0.56 m | wc | 00.08 | 270.000000 | 83283 | Top= 2.54m FCL | Coldwater | X=18.78 | Coldwater
1.28.4 | 00 Ground floor | 83283.5 Pa | 3.10 m | 0.98 m/s | CC= 0.20m FCL | 01 | NNUK=2.89 m | CC= 3.10m FFB | Pipe insulation | ins= 9.000000 mm | CC= 3.10m SSL | ZP150/915 | .004 | Y=13.29 | PW | Dra.no: 1 | 2 | .0028 | 0.13 l/s | 467.999983 l/h | 0.5 m\X\B3/h | Storey: 2 | Edge= 3.09m SSL | NN=2.90 m | wc | 00.08 | 90.000000 | 83283 | Top= 0.19m FCL | Coldwater | X=18.78 | Coldwater
1.29.2 | 00 Ground floor | 83280.4 Pa | 0.75 m | 0.98 m/s | CC= 2.74m FCL | 01 | NNUK=0.54 m | CC= 0.75m FFB | Pipe insulation | ins= 9.000000 mm | CC= 0.75m SSL | ZP150/915 | .002 | Y=12.21 | PW | Dra.no: 1 | 2 | .0029 | 0.13 l/s | 467.999983 l/h | 0.5 m\X\B3/h | Storey: 2 | Edge= 0.75m SSL | NN=0.56 m |  |  | 180.000000 | 83280 | Top= 0.00m FCL | Coldwater | X=18.73 | Coldwater
1.29.3 | 00 Ground floor | 83280.4 Pa | 0.75 m | 0.98 m/s | CC= 2.54m FCL | 01 | NNUK=0.54 m | CC= 0.75m FFB | Pipe insulation | ins= 9.000000 mm | CC= 0.75m SSL | ZP150/915 | .003 | Y=12.21 | PW | Dra.no: 1 | 2 | .0029 | 0.13 l/s | 467.999983 l/h | 0.5 m\X\B3/h | Storey: 2 | Edge= 0.75m SSL | NN=0.56 m | wc | 00.06 | 270.000000 | 83280 | Top= 2.54m FCL | Coldwater | X=18.79 | Coldwater
1.29.4 | 00 Ground floor | 83280.4 Pa | 3.10 m | 0.98 m/s | CC= 0.20m FCL | 01 | NNUK=2.89 m | CC= 3.10m FFB | Pipe insulation | ins= 9.000000 mm | CC= 3.10m SSL | ZP150/915 | .004 | Y=12.21 | PW | Dra.no: 1 | 2 | .0029 | 0.13 l/s | 467.999983 l/h | 0.5 m\X\B3/h | Storey: 2 | Edge= 3.09m SSL | NN=2.90 m | wc | 00.06 | 90.000000 | 83280 | Top= 0.19m FCL | Coldwater | X=18.79 | Coldwater
1.34.1 | 00 Ground floor | 136893.8 Pa | 3.10 m | 0.53 m/s | CC= 0.20m FCL | 01 | NNUK=2.89 m | CC= 3.10m FFB | Pipe insulation | ins= 9.000000 mm | CC= 3.10m SSL | ZP150/915 | .001 | Y=14.95 | PW | Dra.no: 1 | 2 | .0034 | 0.14 l/s | 504.000002 l/h | 0.5 m\X\B3/h | Storey: 2 | Edge= 3.09m SSL | NN=2.90 m | corridor | 00.04 | 0.000000 | 1297 | Top= 0.19m FCL | Coldwater | X=21.99 | Coldwater
1.34.2 | 00 Ground floor | 136893.8 Pa | 3.10 m | 0.53 m/s | CC= 0.20m FCL | 01 | NNUK=2.89 m | CC= 3.10m FFB | Pipe insulation | ins= 9.000000 mm | CC= 3.10m SSL | ZP150/915 | .002 | Y=14.95 | PW | Dra.no: 1 | 2 | .0034 | 0.14 l/s | 504.000002 l/h | 0.5 m\X\B3/h | Storey: 2 | Edge= 3.09m SSL | NN=2.90 m | wc | 00.09 | 180.000000 | 1297 | Top= 0.19m FCL | Coldwater | X=23.31 | Coldwater
1.34.3 | 00 Ground floor | 136893.8 Pa | 3.10 m | 0.53 m/s | CC= 0.20m FCL | 01 | NNUK=2.89 m | CC= 3.10m FFB | Pipe insulation | ins= 9.000000 mm | CC= 3.10m SSL | ZP150/915 | .003 | Y=15.19 | PW | Dra.no: 1 | 2 | .0034 | 0.14 l/s | 504.000002 l/h | 0.5 m\X\B3/h | Storey: 2 | Edge= 3.09m SSL | NN=2.90 m | wc | 00.09 | 90.000000 | 1297 | Top= 0.19m FCL | Coldwater | X=23.31 | Coldwater
1.34.4 | 00 Ground floor | 136893.8 Pa | 0.63 m | 0.53 m/s | CC= 2.67m FCL | 01 | NNUK=0.42 m | CC= 0.63m FFB | Pipe insulation | ins= 9.000000 mm | CC= 0.63m SSL | ZP150/915 | .004 | Y=15.19 | PW | Dra.no: 1 | 2 | .0034 | 0.14 l/s | 504.000002 l/h | 0.5 m\X\B3/h | Storey: 2 | Edge= 0.62m SSL | NN=0.43 m | wc | 00.09 | 90.000000 | 1297 | Top= 2.66m FCL | Coldwater | X=23.31 | Coldwater
1.37.2 | 00 Ground floor | 83373.6 Pa | 0.76 m | 0.98 m/s | CC= 2.74m FCL | 01 | NNUK=0.54 m | CC= 0.76m FFB | Pipe insulation | ins= 9.000000 mm | CC= 0.76m SSL | ZP150/915 | .002 | Y=13.87 | PW | Dra.no: 1 | 2 | .0037 | 0.13 l/s | 467.999983 l/h | 0.5 m\X\B3/h | Storey: 2 | Edge= 0.75m SSL | NN=0.56 m |  |  | 0.000000 | 83374 | Top= 0.00m FCL | Coldwater | X=22.28 | Coldwater
1.37.3 | 00 Ground floor | 83373.6 Pa | 0.76 m | 0.98 m/s | CC= 2.74m FCL | 01 | NNUK=0.54 m | CC= 0.76m FFB | Pipe insulation | ins= 9.000000 mm | CC= 0.76m SSL | ZP150/915 | .003 | Y=13.87 | PW | Dra.no: 1 | 2 | .0037 | 0.13 l/s | 467.999983 l/h | 0.5 m\X\B3/h | Storey: 2 | Edge= 0.75m SSL | NN=0.56 m |  |  | 270.000000 | 83374 | Top= 0.00m FCL | Coldwater | X=22.21 | Coldwater
1.37.4 | 00 Ground floor | 83373.6 Pa | 3.10 m | 0.98 m/s | CC= 0.40m FCL | 01 | NNUK=2.89 m | CC= 3.10m FFB | Pipe insulation | ins= 9.000000 mm | CC= 3.10m SSL | ZP150/915 | .004 | Y=13.87 | PW | Dra.no: 1 | 2 | .0037 | 0.13 l/s | 467.999983 l/h | 0.5 m\X\B3/h | Storey: 2 | Edge= 3.09m SSL | NN=2.90 m |  |  | 90.000000 | 83374 | Top= 0.00m FCL | Coldwater | X=22.21 | Coldwater
1.39.2 | 00 Ground floor | 83380.3 Pa | 0.76 m | 0.98 m/s | CC= 2.74m FCL | 01 | NNUK=0.54 m | CC= 0.76m FFB | Pipe insulation | ins= 9.000000 mm | CC= 0.76m SSL | ZP150/915 | .002 | Y=12.76 | PW | Dra.no: 1 | 2 | .0039 | 0.13 l/s | 467.999983 l/h | 0.5 m\X\B3/h | Storey: 2 | Edge= 0.75m SSL | NN=0.56 m |  |  | 0.000000 | 83380 | Top= 0.00m FCL | Coldwater | X=22.28 | Coldwater
1.39.3 | 00 Ground floor | 83380.3 Pa | 0.76 m | 0.98 m/s | CC= 2.74m FCL | 01 | NNUK=0.54 m | CC= 0.76m FFB | Pipe insulation | ins= 9.000000 mm | CC= 0.76m SSL | ZP150/915 | .003 | Y=12.76 | PW | Dra.no: 1 | 2 | .0039 | 0.13 l/s | 467.999983 l/h | 0.5 m\X\B3/h | Storey: 2 | Edge= 0.75m SSL | NN=0.56 m |  |  | 270.000000 | 83380 | Top= 0.00m FCL | Coldwater | X=22.22 | Coldwater
1.39.4 | 00 Ground floor | 83380.3 Pa | 3.10 m | 0.98 m/s | CC= 0.40m FCL | 01 | NNUK=2.89 m | CC= 3.10m FFB | Pipe insulation | ins= 9.000000 mm | CC= 3.10m SSL | ZP150/915 | .004 | Y=12.76 | PW | Dra.no: 1 | 2 | .0039 | 0.13 l/s | 467.999983 l/h | 0.5 m\X\B3/h | Storey: 2 | Edge= 3.09m SSL | NN=2.90 m |  |  | 90.000000 | 83380 | Top= 0.00m FCL | Coldwater | X=22.22 | Coldwater
1.41.2 | 00 Ground floor | 136329.5 Pa | 3.10 m | 0.53 m/s | CC= 0.20m FCL | 01 | NNUK=2.89 m | CC= 3.10m FFB | Pipe insulation | ins= 9.000000 mm | CC= 3.10m SSL | ZP150/915 | .002 | Y=12.01 | PW | Dra.no: 1 | 2 | .0041 | 0.07 l/s | 252.000001 l/h | 0.3 m\X\B3/h | Storey: 2 | Edge= 3.09m SSL | NN=2.90 m | wc | 00.10 | 90.000000 | 136330 | Top= 0.19m FCL | Coldwater | X=23.11 | Coldwater
1.41.3 | 00 Ground floor | 136329.5 Pa | 0.63 m | 0.53 m/s | CC= 2.67m FCL | 01 | NNUK=0.42 m | CC= 0.63m FFB | Pipe insulation | ins= 9.000000 mm | CC= 0.63m SSL | ZP150/915 | .003 | Y=12.01 | PW | Dra.no: 1 | 2 | .0041 | 0.07 l/s | 252.000001 l/h | 0.3 m\X\B3/h | Storey: 2 | Edge= 0.62m SSL | NN=0.43 m | wc | 00.10 | 270.000000 | 136330 | Top= 2.66m FCL | Coldwater | X=23.11 | Coldwater
2.11.2 | 00 Ground floor | 135269.8 Pa | 3.18 m | 0.53 m/s | CC= 0.12m FCL | 02 | NNUK=2.96 m | CC= 3.18m FFB | Pipe insulation | ins= 9.000000 mm | CC= 3.18m SSL | ZP150/915 | .002 | Y=12.01 |  | Dra.no: 1 | 3 | .0011 | 0.07 l/s | 252.000001 l/h | 0.3 m\X\B3/h | Storey: 2 | Edge= 3.17m SSL | NN=2.98 m | wc | 00.10 | 90.000000 | 135270 | Top= 0.12m FCL | Hotwater | X=23.31 | Hotwater
2.11.3 | 00 Ground floor | 135269.8 Pa | 0.63 m | 0.53 m/s | CC= 2.67m FCL | 02 | NNUK=0.42 m | CC= 0.63m FFB | Pipe insulation | ins= 9.000000 mm | CC= 0.63m SSL | ZP150/915 | .003 | Y=12.01 |  | Dra.no: 1 | 3 | .0011 | 0.07 l/s | 252.000001 l/h | 0.3 m\X\B3/h | Storey: 2 | Edge= 0.62m SSL | NN=0.43 m | wc | 00.10 | 270.000000 | 135270 | Top= 2.66m FCL | Hotwater | X=23.31 | Hotwater
2.2.0 | 00 Ground floor | 0.0 Pa | 2.90 m | 0.00 m/s | CC= 0.28m FCL | 02 | NNUK=2.69 m | CC= 3.02m FFB |  | ins= 0.000000 mm | CC= 3.02m SSL |  | .000 | Y=20.48 | Cooling | Dra.no: 1 | 188 | .0002 | 0.00 l/s | 0.000000 l/h | 0.0 m\X\B3/h | Storey: 2 | Edge= 3.01m SSL | NN=2.70 m | Office | 00.23 | 0.000000 | 0 | Top= 0.27m FCL | Cooling Flow | X=38.67 | Cooling flow
2.2.0 | 00 Ground floor | 0.0 Pa | 2.90 m | 0.00 m/s | CC= 0.28m FCL | 02 | NNUK=2.69 m | CC= 3.02m FFB |  | ins= 0.000000 mm | CC= 3.02m SSL |  | .000 | Y=20.32 | Cooling | Dra.no: 1 | 188 | .0002 | 0.00 l/s | 0.000000 l/h | 0.0 m\X\B3/h | Storey: 2 | Edge= 3.01m SSL | NN=2.70 m | Office | 00.23 | 90.000000 | 0 | Top= 0.27m FCL | Cooling Flow | X=38.67 | Cooling flow
2.2.2 | 00 Ground floor | 185479.5 Pa | 3.18 m | 2.05 m/s | CC= 0.26m FCL | 02 | NNUK=2.96 m | CC= 3.05m FFB | Pipe insulation | ins= 9.000000 mm | CC= 3.05m SSL | ZP150/915 | .002 | Y=11.09 |  | Dra.no: 1 | 3 | .0002 | 0.35 l/s | 1260.000005 l/h | 1.3 m\X\B3/h | Storey: 2 | Edge= 3.04m SSL | NN=2.98 m | Shaft | 00.27 | 90.000000 | 37075 | Top= 0.25m FCL | Hotwater | X=29.36 | Hotwater
2.3.1 | 00 Ground floor | 135820.7 Pa | 3.18 m | 0.53 m/s | CC= 0.12m FCL | 02 | NNUK=2.96 m | CC= 3.18m FFB | Pipe insulation | ins= 9.000000 mm | CC= 3.18m SSL | ZP150/915 | .001 | Y=15.00 |  | Dra.no: 1 | 3 | .0003 | 0.28 l/s | 1008.000004 l/h | 1.0 m\X\B3/h | Storey: 2 | Edge= 3.17m SSL | NN=2.98 m | corridor | 00.04 | 0.000000 | 9386 | Top= 0.12m FCL | Hotwater | X=21.91 | Hotwater
