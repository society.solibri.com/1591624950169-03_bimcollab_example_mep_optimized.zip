Properties of the parts of a building model (IFC2X3), part 3 of 14

# IfcFlowFitting: BE3000018090 (171)
Name | In | Mtg. Above Slab ref Center | Above Sea Level ref. Bottom | Mounting Height | Above Sea Level ref. Center | Main string number | Ins thickness | Room tekst | Mtg. Below Ceiling ref Top | Mtg. Above Slab ref Bottom | X | Y | Room number | Mtg. Below Ceiling ref Center | Model Number | Layer number | Pressure drop | Flow (m\X\B3/h) | Floor number | Flow (l/h) | Part number | Sub string number | Rotation | Medium | Mtg. above Finished Floor ref Center | Flow (l/s) | Abs. pressure | Velocity
Bend | 00 Ground floor | CC= -0.10m SSL | NNUK=-0.31 m | -0.10 m | NN=-0.30 m | 00 | ins= 0.000000 mm | Office | Top= 3.39m FCL | Edge= -0.11m SSL | X=14.07 | Y=22.41 | 00.21 | CC= 3.40m FCL | Dra.no: 1 | 6 | 0 | 0.0 m\X\B3/h | Storey: 2 | 0.000000 l/h | .000 | .0000 | 270.000000 | Heat return | CC= -0.10m FFB | 0.00 l/s | 0.0 Pa | 0.00 m/s
Bend | 00 Ground floor | CC= 0.09m SSL | NNUK=-0.12 m | 0.09 m | NN=-0.11 m | 00 | ins= 0.000000 mm | Storage | Top= 3.20m FCL | Edge= 0.08m SSL | X=23.02 | Y=22.41 | 00.22 | CC= 3.21m FCL | Dra.no: 1 | 5 | 0 | 0.0 m\X\B3/h | Storey: 2 | 0.000000 l/h | .000 | .0000 | 270.000000 | Heat flow | CC= 0.09m FFB | 0.00 l/s | 0.0 Pa | 0.00 m/s
Bend | 00 Ground floor | CC= 0.09m SSL | NNUK=-0.12 m | 0.09 m | NN=-0.11 m | 00 | ins= 0.000000 mm | Office | Top= 3.20m FCL | Edge= 0.08m SSL | X=14.07 | Y=22.41 | 00.21 | CC= 3.21m FCL | Dra.no: 1 | 6 | 0 | 0.0 m\X\B3/h | Storey: 2 | 0.000000 l/h | .000 | .0000 | 270.000000 | Heat return | CC= 0.09m FFB | 0.00 l/s | 0.0 Pa | 0.00 m/s
Bend | 00 Ground floor | CC= 0.09m SSL | NNUK=-0.12 m | 0.09 m | NN=-0.11 m | 00 | ins= 0.000000 mm | Office | Top= 3.20m FCL | Edge= 0.08m SSL | X=14.07 | Y=22.29 | 00.21 | CC= 3.21m FCL | Dra.no: 1 | 6 | 0 | 0.0 m\X\B3/h | Storey: 2 | 0.000000 l/h | .000 | .0000 | 270.000000 | Heat return | CC= 0.09m FFB | 0.00 l/s | 0.0 Pa | 0.00 m/s
Bend | 00 Ground floor | CC= -0.20m SSL | NNUK=-0.41 m | -0.20 m | NN=-0.40 m | 00 | ins= 0.000000 mm | Storage | Top= 3.49m FCL | Edge= -0.21m SSL | X=23.02 | Y=22.41 | 00.22 | CC= 3.50m FCL | Dra.no: 1 | 5 | 0 | 0.0 m\X\B3/h | Storey: 2 | 0.000000 l/h | .000 | .0000 | 270.000000 | Heat flow | CC= -0.20m FFB | 0.00 l/s | 0.0 Pa | 0.00 m/s
Bend | 00 Ground floor | CC= 0.21m SSL | NNUK=-0.12 m | 0.09 m | NN=-0.11 m | 00 | ins= 0.000000 mm | Office | Top= 3.08m FCL | Edge= 0.20m SSL | X=37.95 | Y=22.29 | 00.23 | CC= 3.09m FCL | Dra.no: 1 | 5 | 0 | 0.0 m\X\B3/h | Storey: 2 | 0.000000 l/h | .000 | .0000 | 270.000000 | Heat flow | CC= 0.21m FFB | 0.00 l/s | 0.0 Pa | 0.00 m/s
Bend | 00 Ground floor | CC= -0.20m SSL | NNUK=-0.41 m | -0.20 m | NN=-0.40 m | 00 | ins= 0.000000 mm | Office | Top= 3.49m FCL | Edge= -0.21m SSL | X=11.77 | Y=22.41 | 00.20 | CC= 3.50m FCL | Dra.no: 1 | 5 | 0 | 0.0 m\X\B3/h | Storey: 2 | 0.000000 l/h | .000 | .0000 | 270.000000 | Heat flow | CC= -0.20m FFB | 0.00 l/s | 0.0 Pa | 0.00 m/s
Bend | 00 Ground floor | CC= 0.21m SSL | NNUK=-0.12 m | 0.09 m | NN=-0.11 m | 00 | ins= 0.000000 mm | Office | Top= 3.08m FCL | Edge= 0.20m SSL | X=37.95 | Y=22.41 | 00.23 | CC= 3.09m FCL | Dra.no: 1 | 5 | 0 | 0.0 m\X\B3/h | Storey: 2 | 0.000000 l/h | .000 | .0000 | 270.000000 | Heat flow | CC= 0.21m FFB | 0.00 l/s | 0.0 Pa | 0.00 m/s
Bend | 00 Ground floor | CC= 0.09m SSL | NNUK=-0.12 m | 0.09 m | NN=-0.11 m | 00 | ins= 0.000000 mm | Office | Top= 3.20m FCL | Edge= 0.08m SSL | X=11.77 | Y=22.41 | 00.20 | CC= 3.21m FCL | Dra.no: 1 | 5 | 0 | 0.0 m\X\B3/h | Storey: 2 | 0.000000 l/h | .000 | .0000 | 270.000000 | Heat flow | CC= 0.09m FFB | 0.00 l/s | 0.0 Pa | 0.00 m/s
Bend | 00 Ground floor | CC= 0.09m SSL | NNUK=-0.12 m | 0.09 m | NN=-0.11 m | 00 | ins= 0.000000 mm | Office | Top= 3.20m FCL | Edge= 0.08m SSL | X=11.77 | Y=22.29 | 00.20 | CC= 3.21m FCL | Dra.no: 1 | 5 | 0 | 0.0 m\X\B3/h | Storey: 2 | 0.000000 l/h | .000 | .0000 | 270.000000 | Heat flow | CC= 0.09m FFB | 0.00 l/s | 0.0 Pa | 0.00 m/s
Bend | 00 Ground floor | CC= -0.08m SSL | NNUK=-0.41 m | -0.20 m | NN=-0.40 m | 00 | ins= 0.000000 mm | Office | Top= 3.37m FCL | Edge= -0.09m SSL | X=37.95 | Y=22.41 | 00.23 | CC= 3.38m FCL | Dra.no: 1 | 5 | 0 | 0.0 m\X\B3/h | Storey: 2 | 0.000000 l/h | .000 | .0000 | 270.000000 | Heat flow | CC= -0.08m FFB | 0.00 l/s | 0.0 Pa | 0.00 m/s
Bend | 00 Ground floor | CC= -0.10m SSL | NNUK=-0.31 m | -0.10 m | NN=-0.30 m | 00 | ins= 0.000000 mm | Office | Top= 3.39m FCL | Edge= -0.11m SSL | X=11.82 | Y=22.41 | 00.20 | CC= 3.40m FCL | Dra.no: 1 | 6 | 0 | 0.0 m\X\B3/h | Storey: 2 | 0.000000 l/h | .000 | .0000 | 270.000000 | Heat return | CC= -0.10m FFB | 0.00 l/s | 0.0 Pa | 0.00 m/s
Bend | 00 Ground floor | CC= 0.09m SSL | NNUK=-0.12 m | 0.09 m | NN=-0.11 m | 00 | ins= 0.000000 mm | Office | Top= 3.20m FCL | Edge= 0.08m SSL | X=11.82 | Y=22.41 | 00.20 | CC= 3.21m FCL | Dra.no: 1 | 6 | 0 | 0.0 m\X\B3/h | Storey: 2 | 0.000000 l/h | .000 | .0000 | 270.000000 | Heat return | CC= 0.09m FFB | 0.00 l/s | 0.0 Pa | 0.00 m/s
Bend | 00 Ground floor | CC= 0.21m SSL | NNUK=-0.12 m | 0.09 m | NN=-0.11 m | 00 | ins= 0.000000 mm | Office | Top= 3.08m FCL | Edge= 0.20m SSL | X=35.44 | Y=22.29 | 00.23 | CC= 3.09m FCL | Dra.no: 1 | 6 | 0 | 0.0 m\X\B3/h | Storey: 2 | 0.000000 l/h | .000 | .0000 | 270.000000 | Heat return | CC= 0.21m FFB | 0.00 l/s | 0.0 Pa | 0.00 m/s
Bend | 00 Ground floor | CC= 0.09m SSL | NNUK=-0.12 m | 0.09 m | NN=-0.11 m | 00 | ins= 0.000000 mm | Office | Top= 3.20m FCL | Edge= 0.08m SSL | X=11.82 | Y=22.29 | 00.20 | CC= 3.21m FCL | Dra.no: 1 | 6 | 0 | 0.0 m\X\B3/h | Storey: 2 | 0.000000 l/h | .000 | .0000 | 270.000000 | Heat return | CC= 0.09m FFB | 0.00 l/s | 0.0 Pa | 0.00 m/s
Bend | 00 Ground floor | CC= 0.21m SSL | NNUK=-0.12 m | 0.09 m | NN=-0.11 m | 00 | ins= 0.000000 mm | Office | Top= 3.08m FCL | Edge= 0.20m SSL | X=35.44 | Y=22.41 | 00.23 | CC= 3.09m FCL | Dra.no: 1 | 6 | 0 | 0.0 m\X\B3/h | Storey: 2 | 0.000000 l/h | .000 | .0000 | 270.000000 | Heat return | CC= 0.21m FFB | 0.00 l/s | 0.0 Pa | 0.00 m/s
Bend | 00 Ground floor | CC= -0.20m SSL | NNUK=-0.41 m | -0.20 m | NN=-0.40 m | 00 | ins= 0.000000 mm | Office | Top= 3.49m FCL | Edge= -0.21m SSL | X=9.52 | Y=22.41 | 00.20 | CC= 3.50m FCL | Dra.no: 1 | 5 | 0 | 0.0 m\X\B3/h | Storey: 2 | 0.000000 l/h | .000 | .0000 | 270.000000 | Heat flow | CC= -0.20m FFB | 0.00 l/s | 0.0 Pa | 0.00 m/s
Bend | 00 Ground floor | CC= 0.09m SSL | NNUK=-0.12 m | 0.09 m | NN=-0.11 m | 00 | ins= 0.000000 mm | Office | Top= 3.20m FCL | Edge= 0.08m SSL | X=9.52 | Y=22.41 | 00.20 | CC= 3.21m FCL | Dra.no: 1 | 5 | 0 | 0.0 m\X\B3/h | Storey: 2 | 0.000000 l/h | .000 | .0000 | 270.000000 | Heat flow | CC= 0.09m FFB | 0.00 l/s | 0.0 Pa | 0.00 m/s
Bend | 00 Ground floor | CC= 0.02m SSL | NNUK=-0.31 m | -0.10 m | NN=-0.30 m | 00 | ins= 0.000000 mm | Office | Top= 3.27m FCL | Edge= 0.01m SSL | X=35.44 | Y=22.41 | 00.23 | CC= 3.28m FCL | Dra.no: 1 | 6 | 0 | 0.0 m\X\B3/h | Storey: 2 | 0.000000 l/h | .000 | .0000 | 270.000000 | Heat return | CC= 0.02m FFB | 0.00 l/s | 0.0 Pa | 0.00 m/s
Bend | 00 Ground floor | CC= 0.09m SSL | NNUK=-0.12 m | 0.09 m | NN=-0.11 m | 00 | ins= 0.000000 mm | Office | Top= 3.20m FCL | Edge= 0.08m SSL | X=9.52 | Y=22.29 | 00.20 | CC= 3.21m FCL | Dra.no: 1 | 5 | 0 | 0.0 m\X\B3/h | Storey: 2 | 0.000000 l/h | .000 | .0000 | 270.000000 | Heat flow | CC= 0.09m FFB | 0.00 l/s | 0.0 Pa | 0.00 m/s
Bend | 00 Ground floor | CC= -0.10m SSL | NNUK=-0.31 m | -0.10 m | NN=-0.30 m | 00 | ins= 0.000000 mm | Office | Top= 3.39m FCL | Edge= -0.11m SSL | X=9.57 | Y=22.41 | 00.20 | CC= 3.40m FCL | Dra.no: 1 | 6 | 0 | 0.0 m\X\B3/h | Storey: 2 | 0.000000 l/h | .000 | .0000 | 270.000000 | Heat return | CC= -0.10m FFB | 0.00 l/s | 0.0 Pa | 0.00 m/s
Bend | 00 Ground floor | CC= 0.21m SSL | NNUK=-0.12 m | 0.09 m | NN=-0.11 m | 00 | ins= 0.000000 mm | Office | Top= 3.08m FCL | Edge= 0.20m SSL | X=35.39 | Y=22.29 | 00.23 | CC= 3.09m FCL | Dra.no: 1 | 5 | 0 | 0.0 m\X\B3/h | Storey: 2 | 0.000000 l/h | .000 | .0000 | 270.000000 | Heat flow | CC= 0.21m FFB | 0.00 l/s | 0.0 Pa | 0.00 m/s
Bend | 00 Ground floor | CC= 0.09m SSL | NNUK=-0.12 m | 0.09 m | NN=-0.11 m | 00 | ins= 0.000000 mm | Office | Top= 3.20m FCL | Edge= 0.08m SSL | X=9.57 | Y=22.41 | 00.20 | CC= 3.21m FCL | Dra.no: 1 | 6 | 0 | 0.0 m\X\B3/h | Storey: 2 | 0.000000 l/h | .000 | .0000 | 270.000000 | Heat return | CC= 0.09m FFB | 0.00 l/s | 0.0 Pa | 0.00 m/s
Bend | 00 Ground floor | CC= 0.09m SSL | NNUK=-0.12 m | 0.09 m | NN=-0.11 m | 00 | ins= 0.000000 mm | Office | Top= 3.20m FCL | Edge= 0.08m SSL | X=9.57 | Y=22.29 | 00.20 | CC= 3.21m FCL | Dra.no: 1 | 6 | 0 | 0.0 m\X\B3/h | Storey: 2 | 0.000000 l/h | .000 | .0000 | 270.000000 | Heat return | CC= 0.09m FFB | 0.00 l/s | 0.0 Pa | 0.00 m/s
Bend | 00 Ground floor | CC= 0.21m SSL | NNUK=-0.12 m | 0.09 m | NN=-0.11 m | 00 | ins= 0.000000 mm | Office | Top= 3.08m FCL | Edge= 0.20m SSL | X=35.39 | Y=22.41 | 00.23 | CC= 3.09m FCL | Dra.no: 1 | 5 | 0 | 0.0 m\X\B3/h | Storey: 2 | 0.000000 l/h | .000 | .0000 | 270.000000 | Heat flow | CC= 0.21m FFB | 0.00 l/s | 0.0 Pa | 0.00 m/s
Bend | 00 Ground floor | CC= 0.09m SSL | NNUK=-0.12 m | 0.09 m | NN=-0.11 m | 00 | ins= 0.000000 mm | Office | Top= 3.20m FCL | Edge= 0.08m SSL | X=20.82 | Y=22.41 | 001 | CC= 3.21m FCL | Dra.no: 1 | 6 | 0 | 0.0 m\X\B3/h | Storey: 2 | 0.000000 l/h | .000 | .0000 | 270.000000 | Heat return | CC= 0.09m FFB | 0.00 l/s | 0.0 Pa | 0.00 m/s
Bend | 00 Ground floor | CC= 0.09m SSL | NNUK=-0.12 m | 0.09 m | NN=-0.11 m | 00 | ins= 0.000000 mm | Hallway | Top= 3.20m FCL | Edge= 0.08m SSL | X=25.37 | Y=22.25 | 00.03 | CC= 3.21m FCL | Dra.no: 1 | 6 | 0 | 0.0 m\X\B3/h | Storey: 2 | 0.000000 l/h | .000 | .0000 | 270.000000 | Heat return | CC= 0.09m FFB | 0.00 l/s | 0.0 Pa | 0.00 m/s
Bend | 00 Ground floor | CC= 0.09m SSL | NNUK=-0.12 m | 0.09 m | NN=-0.11 m | 00 | ins= 0.000000 mm | Hallway | Top= 3.20m FCL | Edge= 0.08m SSL | X=25.37 | Y=22.41 | 00.03 | CC= 3.21m FCL | Dra.no: 1 | 6 | 0 | 0.0 m\X\B3/h | Storey: 2 | 0.000000 l/h | .000 | .0000 | 270.000000 | Heat return | CC= 0.09m FFB | 0.00 l/s | 0.0 Pa | 0.00 m/s
Bend | 00 Ground floor | CC= 0.09m SSL | NNUK=-0.12 m | 0.09 m | NN=-0.11 m | 00 | ins= 0.000000 mm | Office | Top= 3.20m FCL | Edge= 0.08m SSL | X=20.77 | Y=22.29 | 001 | CC= 3.21m FCL | Dra.no: 1 | 5 | 0 | 0.0 m\X\B3/h | Storey: 2 | 0.000000 l/h | .000 | .0000 | 270.000000 | Heat flow | CC= 0.09m FFB | 0.00 l/s | 0.0 Pa | 0.00 m/s
Bend | 00 Ground floor | CC= -0.10m SSL | NNUK=-0.31 m | -0.10 m | NN=-0.30 m | 00 | ins= 0.000000 mm | Hallway | Top= 3.39m FCL | Edge= -0.11m SSL | X=25.37 | Y=22.41 | 00.03 | CC= 3.40m FCL | Dra.no: 1 | 6 | 0 | 0.0 m\X\B3/h | Storey: 2 | 0.000000 l/h | .000 | .0000 | 270.000000 | Heat return | CC= -0.10m FFB | 0.00 l/s | 0.0 Pa | 0.00 m/s
Bend | 00 Ground floor | CC= 0.09m SSL | NNUK=-0.12 m | 0.09 m | NN=-0.11 m | 00 | ins= 0.000000 mm | Office | Top= 3.20m FCL | Edge= 0.08m SSL | X=18.52 | Y=22.29 | 001 | CC= 3.21m FCL | Dra.no: 1 | 5 | 0 | 0.0 m\X\B3/h | Storey: 2 | 0.000000 l/h | .000 | .0000 | 270.000000 | Heat flow | CC= 0.09m FFB | 0.00 l/s | 0.0 Pa | 0.00 m/s
Bend | 00 Ground floor | CC= -0.20m SSL | NNUK=-0.41 m | -0.20 m | NN=-0.40 m | 00 | ins= 0.000000 mm | Hallway | Top= 3.49m FCL | Edge= -0.21m SSL | X=25.32 | Y=22.41 | 00.03 | CC= 3.50m FCL | Dra.no: 1 | 5 | 0 | 0.0 m\X\B3/h | Storey: 2 | 0.000000 l/h | .000 | .0000 | 270.000000 | Heat flow | CC= -0.20m FFB | 0.00 l/s | 0.0 Pa | 0.00 m/s
Bend | 00 Ground floor | CC= 0.09m SSL | NNUK=-0.12 m | 0.09 m | NN=-0.11 m | 00 | ins= 0.000000 mm | Hallway | Top= 3.20m FCL | Edge= 0.08m SSL | X=25.32 | Y=22.41 | 00.03 | CC= 3.21m FCL | Dra.no: 1 | 5 | 0 | 0.0 m\X\B3/h | Storey: 2 | 0.000000 l/h | .000 | .0000 | 270.000000 | Heat flow | CC= 0.09m FFB | 0.00 l/s | 0.0 Pa | 0.00 m/s
Bend | 00 Ground floor | CC= 0.09m SSL | NNUK=-0.12 m | 0.09 m | NN=-0.11 m | 00 | ins= 0.000000 mm | Hallway | Top= 3.20m FCL | Edge= 0.08m SSL | X=25.32 | Y=22.25 | 00.03 | CC= 3.21m FCL | Dra.no: 1 | 5 | 0 | 0.0 m\X\B3/h | Storey: 2 | 0.000000 l/h | .000 | .0000 | 270.000000 | Heat flow | CC= 0.09m FFB | 0.00 l/s | 0.0 Pa | 0.00 m/s
Bend | 00 Ground floor | CC= 3.12m SSL | NNUK=2.79 m | 3.00 m | NN=2.80 m | 00 | ins= 0.000000 mm | FB | Top= 0.17m FCL | Edge= 3.11m SSL | X=32.23 | Y=20.42 | 00.16 | CC= 0.18m FCL | Dra.no: 1 | 189 | 0 | 0.0 m\X\B3/h | Storey: 2 | 0.000000 l/h | .000 | .0001 | 0.000000 | Cooling return | CC= 3.12m FFB | 0.00 l/s | 0.0 Pa | 0.00 m/s
Bend | 00 Ground floor | CC= -0.20m SSL | NNUK=-0.41 m | -0.20 m | NN=-0.40 m | 00 | ins= 0.000000 mm | Office | Top= 3.49m FCL | Edge= -0.21m SSL | X=18.52 | Y=22.41 | 001 | CC= 3.50m FCL | Dra.no: 1 | 5 | 0 | 0.0 m\X\B3/h | Storey: 2 | 0.000000 l/h | .000 | .0000 | 270.000000 | Heat flow | CC= -0.20m FFB | 0.00 l/s | 0.0 Pa | 0.00 m/s
Bend | 00 Ground floor | CC= 0.09m SSL | NNUK=-0.12 m | 0.09 m | NN=-0.11 m | 00 | ins= 0.000000 mm | Office | Top= 3.20m FCL | Edge= 0.08m SSL | X=18.52 | Y=22.41 | 001 | CC= 3.21m FCL | Dra.no: 1 | 5 | 0 | 0.0 m\X\B3/h | Storey: 2 | 0.000000 l/h | .000 | .0000 | 270.000000 | Heat flow | CC= 0.09m FFB | 0.00 l/s | 0.0 Pa | 0.00 m/s
Bend | 00 Ground floor | CC= -0.10m SSL | NNUK=-0.31 m | -0.10 m | NN=-0.30 m | 00 | ins= 0.000000 mm | Office | Top= 3.39m FCL | Edge= -0.11m SSL | X=20.82 | Y=22.41 | 001 | CC= 3.40m FCL | Dra.no: 1 | 6 | 0 | 0.0 m\X\B3/h | Storey: 2 | 0.000000 l/h | .000 | .0000 | 270.000000 | Heat return | CC= -0.10m FFB | 0.00 l/s | 0.0 Pa | 0.00 m/s
Bend | 00 Ground floor | CC= 0.09m SSL | NNUK=-0.12 m | 0.09 m | NN=-0.11 m | 00 | ins= 0.000000 mm | Office | Top= 3.20m FCL | Edge= 0.08m SSL | X=20.82 | Y=22.29 | 001 | CC= 3.21m FCL | Dra.no: 1 | 6 | 0 | 0.0 m\X\B3/h | Storey: 2 | 0.000000 l/h | .000 | .0000 | 270.000000 | Heat return | CC= 0.09m FFB | 0.00 l/s | 0.0 Pa | 0.00 m/s
Bend | 00 Ground floor | CC= 0.21m SSL | NNUK=-0.12 m | 0.09 m | NN=-0.11 m | 00 | ins= 0.000000 mm | Director office | Top= 3.08m FCL | Edge= 0.20m SSL | X=38.30 | Y=6.95 | 00.24 | CC= 3.09m FCL | Dra.no: 1 | 6 | 0 | 0.0 m\X\B3/h | Storey: 2 | 0.000000 l/h | .000 | .0000 | 270.000000 | Heat return | CC= 0.21m FFB | 0.00 l/s | 0.0 Pa | 0.00 m/s
Bend | 00 Ground floor | CC= 0.09m SSL | NNUK=-0.12 m | 0.09 m | NN=-0.11 m | 00 | ins= 0.000000 mm | Hallway | Top= 3.20m FCL | Edge= 0.08m SSL | X=27.62 | Y=22.41 | 00.03 | CC= 3.21m FCL | Dra.no: 1 | 6 | 0 | 0.0 m\X\B3/h | Storey: 2 | 0.000000 l/h | .000 | .0000 | 270.000000 | Heat return | CC= 0.09m FFB | 0.00 l/s | 0.0 Pa | 0.00 m/s
Bend | 00 Ground floor | CC= -0.10m SSL | NNUK=-0.31 m | -0.10 m | NN=-0.30 m | 00 | ins= 0.000000 mm | Hallway | Top= 3.39m FCL | Edge= -0.11m SSL | X=27.62 | Y=22.41 | 00.03 | CC= 3.40m FCL | Dra.no: 1 | 6 | 0 | 0.0 m\X\B3/h | Storey: 2 | 0.000000 l/h | .000 | .0000 | 270.000000 | Heat return | CC= -0.10m FFB | 0.00 l/s | 0.0 Pa | 0.00 m/s
Bend | 00 Ground floor | CC= 0.21m SSL | NNUK=-0.12 m | 0.09 m | NN=-0.11 m | 00 | ins= 0.000000 mm | Director office | Top= 3.08m FCL | Edge= 0.20m SSL | X=38.30 | Y=7.06 | 00.24 | CC= 3.09m FCL | Dra.no: 1 | 6 | 0 | 0.0 m\X\B3/h | Storey: 2 | 0.000000 l/h | .000 | .0000 | 270.000000 | Heat return | CC= 0.21m FFB | 0.00 l/s | 0.0 Pa | 0.00 m/s
Bend | 00 Ground floor | CC= 0.09m SSL | NNUK=-0.12 m | 0.09 m | NN=-0.11 m | 00 | ins= 0.000000 mm | Hallway | Top= 3.20m FCL | Edge= 0.08m SSL | X=27.57 | Y=22.25 | 00.03 | CC= 3.21m FCL | Dra.no: 1 | 5 | 0 | 0.0 m\X\B3/h | Storey: 2 | 0.000000 l/h | .000 | .0000 | 270.000000 | Heat flow | CC= 0.09m FFB | 0.00 l/s | 0.0 Pa | 0.00 m/s
Bend | 00 Ground floor | CC= 0.09m SSL | NNUK=-0.12 m | 0.09 m | NN=-0.11 m | 00 | ins= 0.000000 mm | Hallway | Top= 3.20m FCL | Edge= 0.08m SSL | X=27.57 | Y=22.41 | 00.03 | CC= 3.21m FCL | Dra.no: 1 | 5 | 0 | 0.0 m\X\B3/h | Storey: 2 | 0.000000 l/h | .000 | .0000 | 270.000000 | Heat flow | CC= 0.09m FFB | 0.00 l/s | 0.0 Pa | 0.00 m/s
Bend | 00 Ground floor | CC= -0.20m SSL | NNUK=-0.41 m | -0.20 m | NN=-0.40 m | 00 | ins= 0.000000 mm | Office | Top= 3.49m FCL | Edge= -0.21m SSL | X=20.77 | Y=22.41 | 001 | CC= 3.50m FCL | Dra.no: 1 | 5 | 0 | 0.0 m\X\B3/h | Storey: 2 | 0.000000 l/h | .000 | .0000 | 270.000000 | Heat flow | CC= -0.20m FFB | 0.00 l/s | 0.0 Pa | 0.00 m/s
Bend | 00 Ground floor | CC= -0.20m SSL | NNUK=-0.41 m | -0.20 m | NN=-0.40 m | 00 | ins= 0.000000 mm | Hallway | Top= 3.49m FCL | Edge= -0.21m SSL | X=27.57 | Y=22.41 | 00.03 | CC= 3.50m FCL | Dra.no: 1 | 5 | 0 | 0.0 m\X\B3/h | Storey: 2 | 0.000000 l/h | .000 | .0000 | 270.000000 | Heat flow | CC= -0.20m FFB | 0.00 l/s | 0.0 Pa | 0.00 m/s
Bend | 00 Ground floor | CC= 0.09m SSL | NNUK=-0.12 m | 0.09 m | NN=-0.11 m | 00 | ins= 0.000000 mm | Office | Top= 3.20m FCL | Edge= 0.08m SSL | X=20.77 | Y=22.41 | 001 | CC= 3.21m FCL | Dra.no: 1 | 5 | 0 | 0.0 m\X\B3/h | Storey: 2 | 0.000000 l/h | .000 | .0000 | 270.000000 | Heat flow | CC= 0.09m FFB | 0.00 l/s | 0.0 Pa | 0.00 m/s
Bend | 01 First floor | CC= 0.21m SSL | NNUK=3.38 m | 0.09 m | NN=3.39 m | 00 | ins= 0.000000 mm | Storage | Top= 3.08m FCL | Edge= 0.20m SSL | X=22.82 | Y=22.29 | 01.13 | CC= 3.09m FCL | Dra.no: 2 | 5 | 0 | 0.0 m\X\B3/h | Storey: 3 | 0.000000 l/h | .000 | .0000 | 270.000000 | Heat flow | CC= 0.21m FFB | 0.00 l/s | 0.0 Pa | 0.00 m/s
Bend | 01 First floor | CC= -0.08m SSL | NNUK=3.09 m | -0.20 m | NN=3.10 m | 00 | ins= 0.000000 mm | Storage | Top= 3.37m FCL | Edge= -0.09m SSL | X=22.87 | Y=22.41 | 01.13 | CC= 3.38m FCL | Dra.no: 2 | 6 | 0 | 0.0 m\X\B3/h | Storey: 3 | 0.000000 l/h | .000 | .0000 | 270.000000 | Heat return | CC= -0.08m FFB | 0.00 l/s | 0.0 Pa | 0.00 m/s
Bend | 01 First floor | CC= 0.21m SSL | NNUK=3.38 m | 0.09 m | NN=3.39 m | 00 | ins= 0.000000 mm | Office | Top= 3.08m FCL | Edge= 0.20m SSL | X=16.07 | Y=22.41 | 01.20 | CC= 3.09m FCL | Dra.no: 2 | 6 | 0 | 0.0 m\X\B3/h | Storey: 3 | 0.000000 l/h | .000 | .0000 | 270.000000 | Heat return | CC= 0.21m FFB | 0.00 l/s | 0.0 Pa | 0.00 m/s
Bend | 01 First floor | CC= -0.08m SSL | NNUK=3.09 m | -0.20 m | NN=3.10 m | 00 | ins= 0.000000 mm | Office | Top= 3.37m FCL | Edge= -0.09m SSL | X=16.07 | Y=22.41 | 01.20 | CC= 3.38m FCL | Dra.no: 2 | 6 | 0 | 0.0 m\X\B3/h | Storey: 3 | 0.000000 l/h | .000 | .0000 | 270.000000 | Heat return | CC= -0.08m FFB | 0.00 l/s | 0.0 Pa | 0.00 m/s
Bend | 01 First floor | CC= 0.21m SSL | NNUK=3.38 m | 0.09 m | NN=3.39 m | 00 | ins= 0.000000 mm | Office | Top= 3.08m FCL | Edge= 0.20m SSL | X=16.02 | Y=22.29 | 01.20 | CC= 3.09m FCL | Dra.no: 2 | 5 | 0 | 0.0 m\X\B3/h | Storey: 3 | 0.000000 l/h | .000 | .0000 | 270.000000 | Heat flow | CC= 0.21m FFB | 0.00 l/s | 0.0 Pa | 0.00 m/s
Bend | 01 First floor | CC= 0.21m SSL | NNUK=3.38 m | 0.09 m | NN=3.39 m | 00 | ins= 0.000000 mm | Office | Top= 3.08m FCL | Edge= 0.20m SSL | X=16.02 | Y=22.41 | 01.20 | CC= 3.09m FCL | Dra.no: 2 | 5 | 0 | 0.0 m\X\B3/h | Storey: 3 | 0.000000 l/h | .000 | .0000 | 270.000000 | Heat flow | CC= 0.21m FFB | 0.00 l/s | 0.0 Pa | 0.00 m/s
Bend | 01 First floor | CC= 0.02m SSL | NNUK=3.19 m | -0.10 m | NN=3.20 m | 00 | ins= 0.000000 mm | Office | Top= 3.27m FCL | Edge= 0.01m SSL | X=16.02 | Y=22.41 | 01.20 | CC= 3.28m FCL | Dra.no: 2 | 5 | 0 | 0.0 m\X\B3/h | Storey: 3 | 0.000000 l/h | .000 | .0000 | 270.000000 | Heat flow | CC= 0.02m FFB | 0.00 l/s | 0.0 Pa | 0.00 m/s
Bend | 01 First floor | CC= 0.21m SSL | NNUK=3.38 m | 0.09 m | NN=3.39 m | 00 | ins= 0.000000 mm | Office | Top= 3.08m FCL | Edge= 0.20m SSL | X=18.32 | Y=22.29 | 01.19 | CC= 3.09m FCL | Dra.no: 2 | 6 | 0 | 0.0 m\X\B3/h | Storey: 3 | 0.000000 l/h | .000 | .0000 | 270.000000 | Heat return | CC= 0.21m FFB | 0.00 l/s | 0.0 Pa | 0.00 m/s
Bend | 01 First floor | CC= 0.21m SSL | NNUK=3.38 m | 0.09 m | NN=3.39 m | 00 | ins= 0.000000 mm | Office | Top= 3.08m FCL | Edge= 0.20m SSL | X=18.32 | Y=22.41 | 01.19 | CC= 3.09m FCL | Dra.no: 2 | 6 | 0 | 0.0 m\X\B3/h | Storey: 3 | 0.000000 l/h | .000 | .0000 | 270.000000 | Heat return | CC= 0.21m FFB | 0.00 l/s | 0.0 Pa | 0.00 m/s
Bend | 01 First floor | CC= -0.08m SSL | NNUK=3.09 m | -0.20 m | NN=3.10 m | 00 | ins= 0.000000 mm | Office | Top= 3.37m FCL | Edge= -0.09m SSL | X=18.32 | Y=22.41 | 01.19 | CC= 3.38m FCL | Dra.no: 2 | 6 | 0 | 0.0 m\X\B3/h | Storey: 3 | 0.000000 l/h | .000 | .0000 | 270.000000 | Heat return | CC= -0.08m FFB | 0.00 l/s | 0.0 Pa | 0.00 m/s
Bend | 01 First floor | CC= 0.21m SSL | NNUK=3.38 m | 0.09 m | NN=3.39 m | 00 | ins= 0.000000 mm | Office | Top= 3.08m FCL | Edge= 0.20m SSL | X=18.27 | Y=22.29 | 01.19 | CC= 3.09m FCL | Dra.no: 2 | 5 | 0 | 0.0 m\X\B3/h | Storey: 3 | 0.000000 l/h | .000 | .0000 | 270.000000 | Heat flow | CC= 0.21m FFB | 0.00 l/s | 0.0 Pa | 0.00 m/s
Bend | 01 First floor | CC= 0.21m SSL | NNUK=3.38 m | 0.09 m | NN=3.39 m | 00 | ins= 0.000000 mm | Office | Top= 3.08m FCL | Edge= 0.20m SSL | X=18.27 | Y=22.41 | 01.19 | CC= 3.09m FCL | Dra.no: 2 | 5 | 0 | 0.0 m\X\B3/h | Storey: 3 | 0.000000 l/h | .000 | .0000 | 270.000000 | Heat flow | CC= 0.21m FFB | 0.00 l/s | 0.0 Pa | 0.00 m/s
Bend | 01 First floor | CC= 0.02m SSL | NNUK=3.19 m | -0.10 m | NN=3.20 m | 00 | ins= 0.000000 mm | Office | Top= 3.27m FCL | Edge= 0.01m SSL | X=18.27 | Y=22.41 | 01.19 | CC= 3.28m FCL | Dra.no: 2 | 5 | 0 | 0.0 m\X\B3/h | Storey: 3 | 0.000000 l/h | .000 | .0000 | 270.000000 | Heat flow | CC= 0.02m FFB | 0.00 l/s | 0.0 Pa | 0.00 m/s
Bend | 01 First floor | CC= 0.21m SSL | NNUK=3.38 m | 0.09 m | NN=3.39 m | 00 | ins= 0.000000 mm | Office | Top= 3.08m FCL | Edge= 0.20m SSL | X=11.57 | Y=22.29 | 01.18 | CC= 3.09m FCL | Dra.no: 2 | 6 | 0 | 0.0 m\X\B3/h | Storey: 3 | 0.000000 l/h | .000 | .0000 | 270.000000 | Heat return | CC= 0.21m FFB | 0.00 l/s | 0.0 Pa | 0.00 m/s
Bend | 01 First floor | CC= 0.21m SSL | NNUK=3.38 m | 0.09 m | NN=3.39 m | 00 | ins= 0.000000 mm | Office | Top= 3.08m FCL | Edge= 0.20m SSL | X=11.57 | Y=22.41 | 01.18 | CC= 3.09m FCL | Dra.no: 2 | 6 | 0 | 0.0 m\X\B3/h | Storey: 3 | 0.000000 l/h | .000 | .0000 | 270.000000 | Heat return | CC= 0.21m FFB | 0.00 l/s | 0.0 Pa | 0.00 m/s
Bend | 01 First floor | CC= -0.08m SSL | NNUK=3.09 m | -0.20 m | NN=3.10 m | 00 | ins= 0.000000 mm | Office | Top= 3.37m FCL | Edge= -0.09m SSL | X=11.57 | Y=22.41 | 01.18 | CC= 3.38m FCL | Dra.no: 2 | 6 | 0 | 0.0 m\X\B3/h | Storey: 3 | 0.000000 l/h | .000 | .0000 | 270.000000 | Heat return | CC= -0.08m FFB | 0.00 l/s | 0.0 Pa | 0.00 m/s
Bend | 01 First floor | CC= 0.21m SSL | NNUK=3.38 m | 0.09 m | NN=3.39 m | 00 | ins= 0.000000 mm | Office | Top= 3.08m FCL | Edge= 0.20m SSL | X=11.52 | Y=22.29 | 01.18 | CC= 3.09m FCL | Dra.no: 2 | 5 | 0 | 0.0 m\X\B3/h | Storey: 3 | 0.000000 l/h | .000 | .0000 | 270.000000 | Heat flow | CC= 0.21m FFB | 0.00 l/s | 0.0 Pa | 0.00 m/s
Bend | 01 First floor | CC= 0.21m SSL | NNUK=3.38 m | 0.09 m | NN=3.39 m | 00 | ins= 0.000000 mm | Storage | Top= 3.08m FCL | Edge= 0.20m SSL | X=22.87 | Y=22.41 | 01.13 | CC= 3.09m FCL | Dra.no: 2 | 6 | 0 | 0.0 m\X\B3/h | Storey: 3 | 0.000000 l/h | .000 | .0000 | 270.000000 | Heat return | CC= 0.21m FFB | 0.00 l/s | 0.0 Pa | 0.00 m/s
Bend | 01 First floor | CC= 0.21m SSL | NNUK=3.38 m | 0.09 m | NN=3.39 m | 00 | ins= 0.000000 mm | Storage | Top= 3.08m FCL | Edge= 0.20m SSL | X=22.87 | Y=22.29 | 01.13 | CC= 3.09m FCL | Dra.no: 2 | 6 | 0 | 0.0 m\X\B3/h | Storey: 3 | 0.000000 l/h | .000 | .0000 | 270.000000 | Heat return | CC= 0.21m FFB | 0.00 l/s | 0.0 Pa | 0.00 m/s
Bend | 01 First floor | CC= -0.23m SSL | NNUK=3.19 m | -0.10 m | NN=3.20 m | 00 | ins= 0.000000 mm | Office | Top= 3.52m FCL | Edge= -0.24m SSL | X=5.25 | Y=14.42 | 01.17 | CC= 3.53m FCL | Dra.no: 2 | 5 | 0 | 0.0 m\X\B3/h | Storey: 3 | 0.000000 l/h | .000 | .0000 | 270.000000 | Heat flow | CC= -0.23m FFB | 0.00 l/s | 0.0 Pa | 0.00 m/s
Bend | 01 First floor | CC= -0.04m SSL | NNUK=3.38 m | 0.09 m | NN=3.39 m | 00 | ins= 0.000000 mm | Office | Top= 3.33m FCL | Edge= -0.05m SSL | X=5.25 | Y=14.42 | 01.17 | CC= 3.34m FCL | Dra.no: 2 | 5 | 0 | 0.0 m\X\B3/h | Storey: 3 | 0.000000 l/h | .000 | .0000 | 270.000000 | Heat flow | CC= -0.04m FFB | 0.00 l/s | 0.0 Pa | 0.00 m/s
Bend | 01 First floor | CC= -0.04m SSL | NNUK=3.38 m | 0.09 m | NN=3.39 m | 00 | ins= 0.000000 mm | Office | Top= 3.33m FCL | Edge= -0.05m SSL | X=5.36 | Y=14.42 | 01.17 | CC= 3.34m FCL | Dra.no: 2 | 5 | 0 | 0.0 m\X\B3/h | Storey: 3 | 0.000000 l/h | .000 | .0000 | 270.000000 | Heat flow | CC= -0.04m FFB | 0.00 l/s | 0.0 Pa | 0.00 m/s
Bend | 01 First floor | CC= -0.33m SSL | NNUK=3.09 m | -0.20 m | NN=3.10 m | 00 | ins= 0.000000 mm | Office | Top= 3.62m FCL | Edge= -0.34m SSL | X=5.25 | Y=14.47 | 01.17 | CC= 3.63m FCL | Dra.no: 2 | 6 | 0 | 0.0 m\X\B3/h | Storey: 3 | 0.000000 l/h | .000 | .0000 | 270.000000 | Heat return | CC= -0.33m FFB | 0.00 l/s | 0.0 Pa | 0.00 m/s
Bend | 01 First floor | CC= -0.04m SSL | NNUK=3.38 m | 0.09 m | NN=3.39 m | 00 | ins= 0.000000 mm | Office | Top= 3.33m FCL | Edge= -0.05m SSL | X=5.25 | Y=14.47 | 01.17 | CC= 3.34m FCL | Dra.no: 2 | 6 | 0 | 0.0 m\X\B3/h | Storey: 3 | 0.000000 l/h | .000 | .0000 | 270.000000 | Heat return | CC= -0.04m FFB | 0.00 l/s | 0.0 Pa | 0.00 m/s
Bend | 01 First floor | CC= -0.04m SSL | NNUK=3.38 m | 0.09 m | NN=3.39 m | 00 | ins= 0.000000 mm | Office | Top= 3.33m FCL | Edge= -0.05m SSL | X=5.36 | Y=14.47 | 01.17 | CC= 3.34m FCL | Dra.no: 2 | 6 | 0 | 0.0 m\X\B3/h | Storey: 3 | 0.000000 l/h | .000 | .0000 | 270.000000 | Heat return | CC= -0.04m FFB | 0.00 l/s | 0.0 Pa | 0.00 m/s
Bend | 01 First floor | CC= 0.02m SSL | NNUK=3.19 m | -0.10 m | NN=3.20 m | 00 | ins= 0.000000 mm | Office | Top= 3.27m FCL | Edge= 0.01m SSL | X=11.52 | Y=22.41 | 01.18 | CC= 3.28m FCL | Dra.no: 2 | 5 | 0 | 0.0 m\X\B3/h | Storey: 3 | 0.000000 l/h | .000 | .0000 | 270.000000 | Heat flow | CC= 0.02m FFB | 0.00 l/s | 0.0 Pa | 0.00 m/s
Bend | 01 First floor | CC= 0.21m SSL | NNUK=3.38 m | 0.09 m | NN=3.39 m | 00 | ins= 0.000000 mm | Office | Top= 3.08m FCL | Edge= 0.20m SSL | X=11.52 | Y=22.41 | 01.18 | CC= 3.09m FCL | Dra.no: 2 | 5 | 0 | 0.0 m\X\B3/h | Storey: 3 | 0.000000 l/h | .000 | .0000 | 270.000000 | Heat flow | CC= 0.21m FFB | 0.00 l/s | 0.0 Pa | 0.00 m/s
Bend | 01 First floor | CC= 0.21m SSL | NNUK=3.38 m | 0.09 m | NN=3.39 m | 00 | ins= 0.000000 mm | Office | Top= 3.08m FCL | Edge= 0.20m SSL | X=16.07 | Y=22.29 | 01.20 | CC= 3.09m FCL | Dra.no: 2 | 6 | 0 | 0.0 m\X\B3/h | Storey: 3 | 0.000000 l/h | .000 | .0000 | 270.000000 | Heat return | CC= 0.21m FFB | 0.00 l/s | 0.0 Pa | 0.00 m/s
Bend | 01 First floor | CC= -0.04m SSL | NNUK=3.38 m | 0.09 m | NN=3.39 m | 00 | ins= 0.000000 mm | Hallway | Top= 3.33m FCL | Edge= -0.05m SSL | X=27.57 | Y=22.40 | 01.02 | CC= 3.34m FCL | Dra.no: 2 | 6 | 0 | 0.0 m\X\B3/h | Storey: 3 | 0.000000 l/h | .000 | .0000 | 270.000000 | Heat return | CC= -0.04m FFB | 0.00 l/s | 0.0 Pa | 0.00 m/s
Bend | 01 First floor | CC= -0.33m SSL | NNUK=3.09 m | -0.20 m | NN=3.10 m | 00 | ins= 0.000000 mm | Hallway | Top= 3.62m FCL | Edge= -0.34m SSL | X=27.57 | Y=22.40 | 01.02 | CC= 3.63m FCL | Dra.no: 2 | 6 | 0 | 0.0 m\X\B3/h | Storey: 3 | 0.000000 l/h | .000 | .0000 | 270.000000 | Heat return | CC= -0.33m FFB | 0.00 l/s | 0.0 Pa | 0.00 m/s
Bend | 01 First floor | CC= -0.04m SSL | NNUK=3.38 m | 0.09 m | NN=3.39 m | 00 | ins= 0.000000 mm | Hallway | Top= 3.33m FCL | Edge= -0.05m SSL | X=27.52 | Y=22.29 | 01.02 | CC= 3.34m FCL | Dra.no: 2 | 5 | 0 | 0.0 m\X\B3/h | Storey: 3 | 0.000000 l/h | .000 | .0000 | 270.000000 | Heat flow | CC= -0.04m FFB | 0.00 l/s | 0.0 Pa | 0.00 m/s
Bend | 01 First floor | CC= -0.04m SSL | NNUK=3.38 m | 0.09 m | NN=3.39 m | 00 | ins= 0.000000 mm | Hallway | Top= 3.33m FCL | Edge= -0.05m SSL | X=27.52 | Y=22.40 | 01.02 | CC= 3.34m FCL | Dra.no: 2 | 5 | 0 | 0.0 m\X\B3/h | Storey: 3 | 0.000000 l/h | .000 | .0000 | 270.000000 | Heat flow | CC= -0.04m FFB | 0.00 l/s | 0.0 Pa | 0.00 m/s
Bend | 01 First floor | CC= -0.23m SSL | NNUK=3.19 m | -0.10 m | NN=3.20 m | 00 | ins= 0.000000 mm | Hallway | Top= 3.52m FCL | Edge= -0.24m SSL | X=27.52 | Y=22.40 | 01.02 | CC= 3.53m FCL | Dra.no: 2 | 5 | 0 | 0.0 m\X\B3/h | Storey: 3 | 0.000000 l/h | .000 | .0000 | 270.000000 | Heat flow | CC= -0.23m FFB | 0.00 l/s | 0.0 Pa | 0.00 m/s
Bend | 01 First floor | CC= 0.21m SSL | NNUK=3.38 m | 0.09 m | NN=3.39 m | 00 | ins= 0.000000 mm | Storage | Top= 3.08m FCL | Edge= 0.20m SSL | X=22.82 | Y=22.41 | 01.13 | CC= 3.09m FCL | Dra.no: 2 | 5 | 0 | 0.0 m\X\B3/h | Storey: 3 | 0.000000 l/h | .000 | .0000 | 270.000000 | Heat flow | CC= 0.21m FFB | 0.00 l/s | 0.0 Pa | 0.00 m/s
Bend | 01 First floor | CC= 0.02m SSL | NNUK=3.19 m | -0.10 m | NN=3.20 m | 00 | ins= 0.000000 mm | Storage | Top= 3.27m FCL | Edge= 0.01m SSL | X=22.82 | Y=22.41 | 01.13 | CC= 3.28m FCL | Dra.no: 2 | 5 | 0 | 0.0 m\X\B3/h | Storey: 3 | 0.000000 l/h | .000 | .0000 | 270.000000 | Heat flow | CC= 0.02m FFB | 0.00 l/s | 0.0 Pa | 0.00 m/s
Bend | 01 First floor | CC= -0.04m SSL | NNUK=3.38 m | 0.09 m | NN=3.39 m | 00 | ins= 0.000000 mm | Staircase | Top= 3.33m FCL | Edge= -0.05m SSL | X=7.37 | Y=22.29 | 01.05 | CC= 3.34m FCL | Dra.no: 2 | 6 | 0 | 0.0 m\X\B3/h | Storey: 3 | 0.000000 l/h | .000 | .0000 | 270.000000 | Heat return | CC= -0.04m FFB | 0.00 l/s | 0.0 Pa | 0.00 m/s
Bend | 01 First floor | CC= -0.04m SSL | NNUK=3.38 m | 0.09 m | NN=3.39 m | 00 | ins= 0.000000 mm | Staircase | Top= 3.33m FCL | Edge= -0.05m SSL | X=7.37 | Y=22.41 | 01.05 | CC= 3.34m FCL | Dra.no: 2 | 6 | 0 | 0.0 m\X\B3/h | Storey: 3 | 0.000000 l/h | .000 | .0000 | 270.000000 | Heat return | CC= -0.04m FFB | 0.00 l/s | 0.0 Pa | 0.00 m/s
Bend | 01 First floor | CC= -0.33m SSL | NNUK=3.09 m | -0.20 m | NN=3.10 m | 00 | ins= 0.000000 mm | Staircase | Top= 3.62m FCL | Edge= -0.34m SSL | X=7.37 | Y=22.41 | 01.05 | CC= 3.63m FCL | Dra.no: 2 | 6 | 0 | 0.0 m\X\B3/h | Storey: 3 | 0.000000 l/h | .000 | .0000 | 270.000000 | Heat return | CC= -0.33m FFB | 0.00 l/s | 0.0 Pa | 0.00 m/s
Bend | 01 First floor | CC= -0.04m SSL | NNUK=3.38 m | 0.09 m | NN=3.39 m | 00 | ins= 0.000000 mm | Staircase | Top= 3.33m FCL | Edge= -0.05m SSL | X=7.32 | Y=22.29 | 01.05 | CC= 3.34m FCL | Dra.no: 2 | 5 | 0 | 0.0 m\X\B3/h | Storey: 3 | 0.000000 l/h | .000 | .0000 | 270.000000 | Heat flow | CC= -0.04m FFB | 0.00 l/s | 0.0 Pa | 0.00 m/s
Bend | 01 First floor | CC= -0.04m SSL | NNUK=3.38 m | 0.09 m | NN=3.39 m | 00 | ins= 0.000000 mm | Staircase | Top= 3.33m FCL | Edge= -0.05m SSL | X=7.32 | Y=22.41 | 01.05 | CC= 3.34m FCL | Dra.no: 2 | 5 | 0 | 0.0 m\X\B3/h | Storey: 3 | 0.000000 l/h | .000 | .0000 | 270.000000 | Heat flow | CC= -0.04m FFB | 0.00 l/s | 0.0 Pa | 0.00 m/s
Bend | 01 First floor | CC= -0.23m SSL | NNUK=3.19 m | -0.10 m | NN=3.20 m | 00 | ins= 0.000000 mm | Staircase | Top= 3.52m FCL | Edge= -0.24m SSL | X=7.32 | Y=22.41 | 01.05 | CC= 3.53m FCL | Dra.no: 2 | 5 | 0 | 0.0 m\X\B3/h | Storey: 3 | 0.000000 l/h | .000 | .0000 | 270.000000 | Heat flow | CC= -0.23m FFB | 0.00 l/s | 0.0 Pa | 0.00 m/s
Bend | 01 First floor | CC= -0.04m SSL | NNUK=3.38 m | 0.09 m | NN=3.39 m | 00 | ins= 0.000000 mm | Hallway | Top= 3.33m FCL | Edge= -0.05m SSL | X=25.32 | Y=22.29 | 01.02 | CC= 3.34m FCL | Dra.no: 2 | 6 | 0 | 0.0 m\X\B3/h | Storey: 3 | 0.000000 l/h | .000 | .0000 | 270.000000 | Heat return | CC= -0.04m FFB | 0.00 l/s | 0.0 Pa | 0.00 m/s
Bend | 01 First floor | CC= -0.04m SSL | NNUK=3.38 m | 0.09 m | NN=3.39 m | 00 | ins= 0.000000 mm | Hallway | Top= 3.33m FCL | Edge= -0.05m SSL | X=25.32 | Y=22.40 | 01.02 | CC= 3.34m FCL | Dra.no: 2 | 6 | 0 | 0.0 m\X\B3/h | Storey: 3 | 0.000000 l/h | .000 | .0000 | 270.000000 | Heat return | CC= -0.04m FFB | 0.00 l/s | 0.0 Pa | 0.00 m/s
Bend | 01 First floor | CC= -0.33m SSL | NNUK=3.09 m | -0.20 m | NN=3.10 m | 00 | ins= 0.000000 mm | Hallway | Top= 3.62m FCL | Edge= -0.34m SSL | X=25.32 | Y=22.40 | 01.02 | CC= 3.63m FCL | Dra.no: 2 | 6 | 0 | 0.0 m\X\B3/h | Storey: 3 | 0.000000 l/h | .000 | .0000 | 270.000000 | Heat return | CC= -0.33m FFB | 0.00 l/s | 0.0 Pa | 0.00 m/s
Bend | 01 First floor | CC= -0.04m SSL | NNUK=3.38 m | 0.09 m | NN=3.39 m | 00 | ins= 0.000000 mm | Hallway | Top= 3.33m FCL | Edge= -0.05m SSL | X=25.27 | Y=22.29 | 01.02 | CC= 3.34m FCL | Dra.no: 2 | 5 | 0 | 0.0 m\X\B3/h | Storey: 3 | 0.000000 l/h | .000 | .0000 | 270.000000 | Heat flow | CC= -0.04m FFB | 0.00 l/s | 0.0 Pa | 0.00 m/s
Bend | 01 First floor | CC= -0.04m SSL | NNUK=3.38 m | 0.09 m | NN=3.39 m | 00 | ins= 0.000000 mm | Hallway | Top= 3.33m FCL | Edge= -0.05m SSL | X=27.57 | Y=22.29 | 01.02 | CC= 3.34m FCL | Dra.no: 2 | 6 | 0 | 0.0 m\X\B3/h | Storey: 3 | 0.000000 l/h | .000 | .0000 | 270.000000 | Heat return | CC= -0.04m FFB | 0.00 l/s | 0.0 Pa | 0.00 m/s
Bend | 01 First floor | CC= -0.04m SSL | NNUK=3.38 m | 0.09 m | NN=3.39 m | 00 | ins= 0.000000 mm | Hallway | Top= 3.33m FCL | Edge= -0.05m SSL | X=25.27 | Y=22.40 | 01.02 | CC= 3.34m FCL | Dra.no: 2 | 5 | 0 | 0.0 m\X\B3/h | Storey: 3 | 0.000000 l/h | .000 | .0000 | 270.000000 | Heat flow | CC= -0.04m FFB | 0.00 l/s | 0.0 Pa | 0.00 m/s
Bend | 01 First floor | CC= -0.23m SSL | NNUK=3.19 m | -0.10 m | NN=3.20 m | 00 | ins= 0.000000 mm | Hallway | Top= 3.52m FCL | Edge= -0.24m SSL | X=25.27 | Y=22.40 | 01.02 | CC= 3.53m FCL | Dra.no: 2 | 5 | 0 | 0.0 m\X\B3/h | Storey: 3 | 0.000000 l/h | .000 | .0000 | 270.000000 | Heat flow | CC= -0.23m FFB | 0.00 l/s | 0.0 Pa | 0.00 m/s

# IfcFlowFitting: BE3000022090 (39)
Type - Description: Cu fitting bend 90\X\B0 22x1 mm; ApplicableOccurrence: Basic; PredefinedType: BEND
Type - Pset_ManufacturerTypeInformation - ArticleNumber: BE3000022090; ModelReference: Cu fitting bend 90\X\B0 22x1 mm; Manufacturer: DDS
Type - Pset_PipeFittingTypeCommon - SubType: Bend 90 degree; NominalDiameter: 20; InnerDiameter: 20; OuterDiameter: 22
Material: IFC Building Material
Pset_DDS - Pipe thickness:: x1.0; Dimension DN: 20 mm; Manufacturer: DDS; Width: 20; Product: Cu fitting bend 90\X\B0 22x1 mm; Project name: OpenBIM; Height: 0; Insulation k-value: 0; Insulation WSVO: 0; Outside dimension: 22.000000; Product Number: BE3000022090; Length: 90.0 m; Building Part: Building: 0
AC_Pset_RenovationAndPhasing - Renovation Status: Existing
Name | In | Mtg. Above Slab ref Bottom | Mounting Height | Above Sea Level ref. Bottom | Y | Flow (l/h) | Main string number | Mtg. above Finished Floor ref Center | Rotation | Ins thickness | Mtg. Above Slab ref Center | Part number | Mtg. Below Ceiling ref Center | Above Sea Level ref. Center | Model Number | Layer number | Flow (m\X\B3/h) | X | Floor number | Velocity | Pressure drop | Sub string number | Flow (l/s) | Medium | Mtg. Below Ceiling ref Top | Abs. pressure | Room number | Room tekst
1.1.24 | -01 Foundation | Edge= -0.01m SSL | 0.00 m | NNUK=-1.02 m | Y=11.21 | 6731.999856 l/h | 01 | CC= 0.00m FFB | 270.000000 | ins= 9.000000 mm | CC= 0.00m SSL | .024 | CC= 0.67m FCL | NN=-1.00 m | Dra.no: 0 | 2 | 6.7 m\X\B3/h | X=29.97 | Storey: 1 | 2.31 m/s | 106751 | .0001 | 1.87 l/s | Coldwater | Top= 0.00m FCL | 351157.7 Pa | Pset_DDS - Insulation product text: Pipe insulation; Insulation product number: ZP150/922; Group: Coldwater
1.1.27 | 00 Ground floor | Edge= 0.36m SSL | 0.50 m | NNUK=0.28 m | Y=11.21 | 6731.999856 l/h | 01 | CC= 0.37m FFB | 270.000000 | ins= 9.000000 mm | CC= 0.37m SSL | .027 | CC= 2.93m FCL | NN=0.30 m | Dra.no: 1 | 2 | 6.7 m\X\B3/h | X=29.97 | Storey: 2 | 2.31 m/s | 106751 | .0001 | 1.87 l/s | Coldwater | Top= 2.92m FCL | 351157.7 Pa | 00.27 | Shaft | Pset_DDS - Insulation product text: Pipe insulation; Insulation product number: ZP150/922; System Name: PW; Group: Coldwater
1.1.28 | 00 Ground floor | Edge= 0.36m SSL | 0.50 m | NNUK=0.28 m | Y=10.62 | 6731.999856 l/h | 01 | CC= 0.37m FFB | 0.000000 | ins= 9.000000 mm | CC= 0.37m SSL | .028 | CC= 2.93m FCL | NN=0.30 m | Dra.no: 1 | 2 | 6.7 m\X\B3/h | X=29.97 | Storey: 2 | 2.31 m/s | 106751 | .0001 | 1.87 l/s | Coldwater | Top= 2.92m FCL | 351157.7 Pa | 00.15 | FB | Pset_DDS - Insulation product text: Pipe insulation; Insulation product number: ZP150/922; System Name: PW; Group: Coldwater
1.1.32 | 00 Ground floor | Edge= 0.36m SSL | 0.50 m | NNUK=0.28 m | Y=10.62 | 6731.999856 l/h | 01 | CC= 0.37m FFB | 0.000000 | ins= 9.000000 mm | CC= 0.37m SSL | .032 | CC= 2.93m FCL | NN=0.30 m | Dra.no: 1 | 2 | 6.7 m\X\B3/h | X=29.36 | Storey: 2 | 2.31 m/s | 106751 | .0001 | 1.87 l/s | Coldwater | Top= 2.92m FCL | 351157.7 Pa | 00.15 | FB | Pset_DDS - Insulation product text: Pipe insulation; Insulation product number: ZP150/922; System Name: PW; Group: Coldwater
1.1.33 | 00 Ground floor | Edge= 0.36m SSL | 0.50 m | NNUK=0.28 m | Y=10.94 | 6731.999856 l/h | 01 | CC= 0.37m FFB | 270.000000 | ins= 9.000000 mm | CC= 0.37m SSL | .033 | CC= 2.93m FCL | NN=0.30 m | Dra.no: 1 | 2 | 6.7 m\X\B3/h | X=29.36 | Storey: 2 | 2.31 m/s | 106751 | .0001 | 1.87 l/s | Coldwater | Top= 2.92m FCL | 351157.7 Pa | 00.27 | Shaft | Pset_DDS - Insulation product text: Pipe insulation; Insulation product number: ZP150/922; System Name: PW; Group: Coldwater
2.1.0 | 00 Ground floor | Edge= 2.79m SSL | 2.80 m | NNUK=2.58 m | Y=13.25 | 0.000000 l/h | 02 | CC= 2.80m FFB | 180.000000 | ins= 0.000000 mm | CC= 2.80m SSL | .000 | CC= 0.50m FCL | NN=2.60 m | Dra.no: 1 | 188 | 0.0 m\X\B3/h | X=32.17 | Storey: 2 | 0.00 m/s | 0 | .0001 | 0.00 l/s | Cooling Flow | Top= 0.49m FCL | 0.0 Pa | 00.03 | Hallway | Group: Cooling flow; Pset_DDS - System Name: Cooling
3.1.0 | 00 Ground floor | Edge= 2.79m SSL | 2.80 m | NNUK=2.58 m | Y=13.18 | 0.000000 l/h | 03 | CC= 2.80m FFB | 180.000000 | ins= 0.000000 mm | CC= 2.80m SSL | .000 | CC= 0.50m FCL | NN=2.60 m | Dra.no: 1 | 189 | 0.0 m\X\B3/h | X=32.23 | Storey: 2 | 0.00 m/s | 0 | .0001 | 0.00 l/s | Cooling return | Top= 0.49m FCL | 0.0 Pa | 00.03 | Hallway | Group: Cooling return; Pset_DDS - System Name: Cooling
Bend | 00 Ground floor | Edge= -0.24m SSL | -0.10 m | NNUK=-0.32 m | Y=7.27 | 0.000000 l/h | 00 | CC= -0.23m FFB | 180.000000 | ins= 0.000000 mm | CC= -0.23m SSL | .000 | CC= 3.53m FCL | NN=-0.30 m | Dra.no: 1 | 6 | 0.0 m\X\B3/h | X=34.57 | Storey: 2 | 0.00 m/s | 0 | .0000 | 0.00 l/s | Heat return | Top= 3.52m FCL | 0.0 Pa | 00.25 | Director office
Bend | 00 Ground floor | Edge= -0.24m SSL | -0.10 m | NNUK=-0.32 m | Y=6.95 | 0.000000 l/h | 00 | CC= -0.23m FFB | 270.000000 | ins= 0.000000 mm | CC= -0.23m SSL | .000 | CC= 3.53m FCL | NN=-0.30 m | Dra.no: 1 | 6 | 0.0 m\X\B3/h | X=34.57 | Storey: 2 | 0.00 m/s | 0 | .0000 | 0.00 l/s | Heat return | Top= 3.52m FCL | 0.0 Pa | 00.25 | Director office
Bend | 00 Ground floor | Edge= 0.01m SSL | -0.10 m | NNUK=-0.32 m | Y=7.27 | 0.000000 l/h | 00 | CC= 0.02m FFB | 0.000000 | ins= 0.000000 mm | CC= 0.02m SSL | .000 | CC= 3.28m FCL | NN=-0.30 m | Dra.no: 1 | 6 | 0.0 m\X\B3/h | X=40.54 | Storey: 2 | 0.00 m/s | 0 | .0000 | 0.00 l/s | Heat return | Top= 3.27m FCL | 0.0 Pa | 00.24 | Director office
Bend | 00 Ground floor | Edge= -0.05m SSL | 0.09 m | NNUK=-0.13 m | Y=6.95 | 0.000000 l/h | 00 | CC= -0.04m FFB | 270.000000 | ins= 0.000000 mm | CC= -0.04m SSL | .000 | CC= 3.34m FCL | NN=-0.11 m | Dra.no: 1 | 6 | 0.0 m\X\B3/h | X=34.57 | Storey: 2 | 0.00 m/s | 0 | .0000 | 0.00 l/s | Heat return | Top= 3.33m FCL | 0.0 Pa | 00.25 | Director office
Bend | 00 Ground floor | Edge= 0.01m SSL | -0.10 m | NNUK=-0.32 m | Y=21.96 | 0.000000 l/h | 00 | CC= 0.02m FFB | 0.000000 | ins= 0.000000 mm | CC= 0.02m SSL | .000 | CC= 3.28m FCL | NN=-0.30 m | Dra.no: 1 | 6 | 0.0 m\X\B3/h | X=40.54 | Storey: 2 | 0.00 m/s | 0 | .0000 | 0.00 l/s | Heat return | Top= 3.27m FCL | 0.0 Pa | 00.23 | Office
Bend | 00 Ground floor | Edge= -0.05m SSL | 0.09 m | NNUK=-0.13 m | Y=7.06 | 0.000000 l/h | 00 | CC= -0.04m FFB | 270.000000 | ins= 0.000000 mm | CC= -0.04m SSL | .000 | CC= 3.34m FCL | NN=-0.11 m | Dra.no: 1 | 6 | 0.0 m\X\B3/h | X=34.57 | Storey: 2 | 0.00 m/s | 0 | .0000 | 0.00 l/s | Heat return | Top= 3.33m FCL | 0.0 Pa | 00.25 | Director office
Bend | 00 Ground floor | Edge= -0.11m SSL | -0.10 m | NNUK=-0.32 m | Y=11.83 | 0.000000 l/h | 00 | CC= -0.10m FFB | 0.000000 | ins= 0.000000 mm | CC= -0.10m SSL | .000 | CC= 3.60m FCL | NN=-0.30 m | Dra.no: 1 | 6 | 0.0 m\X\B3/h | X=28.57 | Storey: 2 | 0.00 m/s | 0 | .0000 | 0.00 l/s | Heat return | Top= 3.59m FCL | 0.0 Pa | 00.01 | Entrance
Bend | 00 Ground floor | Edge= -0.05m SSL | 0.09 m | NNUK=-0.13 m | Y=7.06 | 0.000000 l/h | 00 | CC= -0.04m FFB | 270.000000 | ins= 0.000000 mm | CC= -0.04m SSL | .000 | CC= 3.34m FCL | NN=-0.11 m | Dra.no: 1 | 5 | 0.0 m\X\B3/h | X=34.62 | Storey: 2 | 0.00 m/s | 0 | .0000 | 0.00 l/s | Heat flow | Top= 3.33m FCL | 0.0 Pa | 00.25 | Director office
Bend | 00 Ground floor | Edge= -0.05m SSL | 0.09 m | NNUK=-0.13 m | Y=6.95 | 0.000000 l/h | 00 | CC= -0.04m FFB | 270.000000 | ins= 0.000000 mm | CC= -0.04m SSL | .000 | CC= 3.34m FCL | NN=-0.11 m | Dra.no: 1 | 5 | 0.0 m\X\B3/h | X=34.62 | Storey: 2 | 0.00 m/s | 0 | .0000 | 0.00 l/s | Heat flow | Top= 3.33m FCL | 0.0 Pa | 00.25 | Director office
Bend | 00 Ground floor | Edge= -0.34m SSL | -0.20 m | NNUK=-0.42 m | Y=6.95 | 0.000000 l/h | 00 | CC= -0.33m FFB | 270.000000 | ins= 0.000000 mm | CC= -0.33m SSL | .000 | CC= 3.63m FCL | NN=-0.40 m | Dra.no: 1 | 5 | 0.0 m\X\B3/h | X=34.62 | Storey: 2 | 0.00 m/s | 0 | .0000 | 0.00 l/s | Heat flow | Top= 3.62m FCL | 0.0 Pa | 00.25 | Director office
Bend | 00 Ground floor | Edge= -0.34m SSL | -0.20 m | NNUK=-0.42 m | Y=7.16 | 0.000000 l/h | 00 | CC= -0.33m FFB | 180.000000 | ins= 0.000000 mm | CC= -0.33m SSL | .000 | CC= 3.63m FCL | NN=-0.40 m | Dra.no: 1 | 5 | 0.0 m\X\B3/h | X=34.62 | Storey: 2 | 0.00 m/s | 0 | .0000 | 0.00 l/s | Heat flow | Top= 3.62m FCL | 0.0 Pa | 00.25 | Director office
Bend | 00 Ground floor | Edge= -0.09m SSL | -0.20 m | NNUK=-0.42 m | Y=7.16 | 0.000000 l/h | 00 | CC= -0.08m FFB | 0.000000 | ins= 0.000000 mm | CC= -0.08m SSL | .000 | CC= 3.38m FCL | NN=-0.40 m | Dra.no: 1 | 5 | 0.0 m\X\B3/h | X=40.65 | Storey: 2 | 0.00 m/s | 0 | .0000 | 0.00 l/s | Heat flow | Top= 3.37m FCL | 0.0 Pa | 00.24 | Director office
Bend | 00 Ground floor | Edge= -0.09m SSL | -0.20 m | NNUK=-0.42 m | Y=22.09 | 0.000000 l/h | 00 | CC= -0.08m FFB | 0.000000 | ins= 0.000000 mm | CC= -0.08m SSL | .000 | CC= 3.38m FCL | NN=-0.40 m | Dra.no: 1 | 5 | 0.0 m\X\B3/h | X=40.65 | Storey: 2 | 0.00 m/s | 0 | .0000 | 0.00 l/s | Heat flow | Top= 3.37m FCL | 0.0 Pa | 00.23 | Office
Bend | 00 Ground floor | Edge= -0.21m SSL | -0.20 m | NNUK=-0.42 m | Y=11.94 | 0.000000 l/h | 00 | CC= -0.20m FFB | 0.000000 | ins= 0.000000 mm | CC= -0.20m SSL | .000 | CC= 3.70m FCL | NN=-0.40 m | Dra.no: 1 | 5 | 0.0 m\X\B3/h | X=28.67 | Storey: 2 | 0.00 m/s | 0 | .0000 | 0.00 l/s | Heat flow | Top= 3.69m FCL | 0.0 Pa | 00.01 | Entrance
Bend | 01 First floor | Edge= -0.24m SSL | -0.10 m | NNUK=3.18 m | Y=22.18 | 0.000000 l/h | 00 | CC= -0.23m FFB | 180.000000 | ins= 0.000000 mm | CC= -0.23m SSL | .000 | CC= 3.53m FCL | NN=3.20 m | Dra.no: 2 | 5 | 0.0 m\X\B3/h | X=5.51 | Storey: 3 | 0.00 m/s | 0 | .0000 | 0.00 l/s | Heat flow | Top= 3.52m FCL | 0.0 Pa | 01.05 | Staircase
Bend | 01 First floor | Edge= -0.24m SSL | -0.10 m | NNUK=3.18 m | Y=12.22 | 0.000000 l/h | 00 | CC= -0.23m FFB | 0.000000 | ins= 0.000000 mm | CC= -0.23m SSL | .000 | CC= 3.53m FCL | NN=3.20 m | Dra.no: 2 | 5 | 0.0 m\X\B3/h | X=5.51 | Storey: 3 | 0.00 m/s | 0 | .0000 | 0.00 l/s | Heat flow | Top= 3.52m FCL | 0.0 Pa | 01.17 | Office
Bend | 01 First floor | Edge= -0.34m SSL | -0.20 m | NNUK=3.08 m | Y=12.27 | 0.000000 l/h | 00 | CC= -0.33m FFB | 0.000000 | ins= 0.000000 mm | CC= -0.33m SSL | .000 | CC= 3.63m FCL | NN=3.10 m | Dra.no: 2 | 6 | 0.0 m\X\B3/h | X=5.65 | Storey: 3 | 0.00 m/s | 0 | .0000 | 0.00 l/s | Heat return | Top= 3.62m FCL | 0.0 Pa | 01.17 | Office
Bend | 01 First floor | Edge= -0.34m SSL | -0.20 m | NNUK=3.08 m | Y=22.06 | 0.000000 l/h | 00 | CC= -0.33m FFB | 180.000000 | ins= 0.000000 mm | CC= -0.33m SSL | .000 | CC= 3.63m FCL | NN=3.10 m | Dra.no: 2 | 6 | 0.0 m\X\B3/h | X=5.65 | Storey: 3 | 0.00 m/s | 0 | .0000 | 0.00 l/s | Heat return | Top= 3.62m FCL | 0.0 Pa | 01.05 | Staircase
Bend | 01 First floor | Edge= -0.34m SSL | -0.20 m | NNUK=3.08 m | Y=11.83 | 0.000000 l/h | 00 | CC= -0.33m FFB | 180.000000 | ins= 0.000000 mm | CC= -0.33m SSL | .000 | CC= 3.63m FCL | NN=3.10 m | Dra.no: 2 | 6 | 0.0 m\X\B3/h | X=26.32 | Storey: 3 | 0.00 m/s | 0 | .0000 | 0.00 l/s | Heat return | Top= 3.62m FCL | 0.0 Pa | 01.03 | Restaurant
Bend | 01 First floor | Edge= -0.34m SSL | -0.20 m | NNUK=3.08 m | Y=11.64 | 0.000000 l/h | 00 | CC= -0.33m FFB | 0.000000 | ins= 0.000000 mm | CC= -0.33m SSL | .000 | CC= 3.63m FCL | NN=3.10 m | Dra.no: 2 | 6 | 0.0 m\X\B3/h | X=26.32 | Storey: 3 | 0.00 m/s | 0 | .0000 | 0.00 l/s | Heat return | Top= 3.62m FCL | 0.0 Pa | 01.03 | Restaurant
Bend | 01 First floor | Edge= -0.34m SSL | -0.20 m | NNUK=3.08 m | Y=11.64 | 0.000000 l/h | 00 | CC= -0.33m FFB | 0.000000 | ins= 0.000000 mm | CC= -0.33m SSL | .000 | CC= 3.63m FCL | NN=3.10 m | Dra.no: 2 | 6 | 0.0 m\X\B3/h | X=25.50 | Storey: 3 | 0.00 m/s | 0 | .0000 | 0.00 l/s | Heat return | Top= 3.62m FCL | 0.0 Pa | 01.03 | Restaurant
Bend | 01 First floor | Edge= -0.34m SSL | -0.20 m | NNUK=3.08 m | Y=22.06 | 0.000000 l/h | 00 | CC= -0.33m FFB | 180.000000 | ins= 0.000000 mm | CC= -0.33m SSL | .000 | CC= 3.63m FCL | NN=3.10 m | Dra.no: 2 | 6 | 0.0 m\X\B3/h | X=30.32 | Storey: 3 | 0.00 m/s | 0 | .0000 | 0.00 l/s | Heat return | Top= 3.62m FCL | 0.0 Pa | 01.02 | Hallway
Bend | 01 First floor | Edge= -0.05m SSL | 0.09 m | NNUK=3.37 m | Y=22.29 | 0.000000 l/h | 00 | CC= -0.04m FFB | 270.000000 | ins= 0.000000 mm | CC= -0.04m SSL | .000 | CC= 3.34m FCL | NN=3.39 m | Dra.no: 2 | 6 | 0.0 m\X\B3/h | X=30.32 | Storey: 3 | 0.00 m/s | 0 | .0000 | 0.00 l/s | Heat return | Top= 3.33m FCL | 0.0 Pa | 01.02 | Hallway
Bend | 01 First floor | Edge= -0.34m SSL | -0.20 m | NNUK=3.08 m | Y=22.40 | 0.000000 l/h | 00 | CC= -0.33m FFB | 270.000000 | ins= 0.000000 mm | CC= -0.33m SSL | .000 | CC= 3.63m FCL | NN=3.10 m | Dra.no: 2 | 6 | 0.0 m\X\B3/h | X=30.32 | Storey: 3 | 0.00 m/s | 0 | .0000 | 0.00 l/s | Heat return | Top= 3.62m FCL | 0.0 Pa | 01.02 | Hallway
Bend | 01 First floor | Edge= -0.05m SSL | 0.09 m | NNUK=3.37 m | Y=22.40 | 0.000000 l/h | 00 | CC= -0.04m FFB | 270.000000 | ins= 0.000000 mm | CC= -0.04m SSL | .000 | CC= 3.34m FCL | NN=3.39 m | Dra.no: 2 | 6 | 0.0 m\X\B3/h | X=30.32 | Storey: 3 | 0.00 m/s | 0 | .0000 | 0.00 l/s | Heat return | Top= 3.33m FCL | 0.0 Pa | 01.02 | Hallway
Bend | 01 First floor | Edge= -0.24m SSL | -0.10 m | NNUK=3.18 m | Y=11.94 | 0.000000 l/h | 00 | CC= -0.23m FFB | 180.000000 | ins= 0.000000 mm | CC= -0.23m SSL | .000 | CC= 3.53m FCL | NN=3.20 m | Dra.no: 2 | 5 | 0.0 m\X\B3/h | X=26.21 | Storey: 3 | 0.00 m/s | 0 | .0000 | 0.00 l/s | Heat flow | Top= 3.52m FCL | 0.0 Pa | 01.03 | Restaurant
Bend | 01 First floor | Edge= -0.24m SSL | -0.10 m | NNUK=3.18 m | Y=11.73 | 0.000000 l/h | 00 | CC= -0.23m FFB | 0.000000 | ins= 0.000000 mm | CC= -0.23m SSL | .000 | CC= 3.53m FCL | NN=3.20 m | Dra.no: 2 | 5 | 0.0 m\X\B3/h | X=26.21 | Storey: 3 | 0.00 m/s | 0 | .0000 | 0.00 l/s | Heat flow | Top= 3.52m FCL | 0.0 Pa | 01.03 | Restaurant
Bend | 01 First floor | Edge= -0.24m SSL | -0.10 m | NNUK=3.18 m | Y=11.73 | 0.000000 l/h | 00 | CC= -0.23m FFB | 0.000000 | ins= 0.000000 mm | CC= -0.23m SSL | .000 | CC= 3.53m FCL | NN=3.20 m | Dra.no: 2 | 5 | 0.0 m\X\B3/h | X=25.60 | Storey: 3 | 0.00 m/s | 0 | .0000 | 0.00 l/s | Heat flow | Top= 3.52m FCL | 0.0 Pa | 01.03 | Restaurant
Bend | 01 First floor | Edge= -0.24m SSL | -0.10 m | NNUK=3.18 m | Y=22.18 | 0.000000 l/h | 00 | CC= -0.23m FFB | 180.000000 | ins= 0.000000 mm | CC= -0.23m SSL | .000 | CC= 3.53m FCL | NN=3.20 m | Dra.no: 2 | 5 | 0.0 m\X\B3/h | X=30.27 | Storey: 3 | 0.00 m/s | 0 | .0000 | 0.00 l/s | Heat flow | Top= 3.52m FCL | 0.0 Pa | 01.02 | Hallway
Bend | 01 First floor | Edge= -0.24m SSL | -0.10 m | NNUK=3.18 m | Y=22.40 | 0.000000 l/h | 00 | CC= -0.23m FFB | 270.000000 | ins= 0.000000 mm | CC= -0.23m SSL | .000 | CC= 3.53m FCL | NN=3.20 m | Dra.no: 2 | 5 | 0.0 m\X\B3/h | X=30.27 | Storey: 3 | 0.00 m/s | 0 | .0000 | 0.00 l/s | Heat flow | Top= 3.52m FCL | 0.0 Pa | 01.02 | Hallway
Bend | 01 First floor | Edge= -0.05m SSL | 0.09 m | NNUK=3.37 m | Y=22.40 | 0.000000 l/h | 00 | CC= -0.04m FFB | 270.000000 | ins= 0.000000 mm | CC= -0.04m SSL | .000 | CC= 3.34m FCL | NN=3.39 m | Dra.no: 2 | 5 | 0.0 m\X\B3/h | X=30.27 | Storey: 3 | 0.00 m/s | 0 | .0000 | 0.00 l/s | Heat flow | Top= 3.33m FCL | 0.0 Pa | 01.02 | Hallway
Bend | 01 First floor | Edge= -0.05m SSL | 0.09 m | NNUK=3.37 m | Y=22.29 | 0.000000 l/h | 00 | CC= -0.04m FFB | 270.000000 | ins= 0.000000 mm | CC= -0.04m SSL | .000 | CC= 3.34m FCL | NN=3.39 m | Dra.no: 2 | 5 | 0.0 m\X\B3/h | X=30.27 | Storey: 3 | 0.00 m/s | 0 | .0000 | 0.00 l/s | Heat flow | Top= 3.33m FCL | 0.0 Pa | 01.02 | Hallway

# IfcFlowFitting: BE3000028090 (13)
Type - Description: Cu fitting bend 90\X\B0 28x1,5 mm; ApplicableOccurrence: Basic; PredefinedType: BEND
Type - Pset_ManufacturerTypeInformation - ArticleNumber: BE3000028090; ModelReference: Cu fitting bend 90\X\B0 28x1,5 mm; Manufacturer: DDS
Type - Pset_PipeFittingTypeCommon - SubType: Bend 90 degree; NominalDiameter: 25; InnerDiameter: 25; OuterDiameter: 28
Material: IFC Building Material
Pset_DDS - Product: Cu fitting bend 90\X\B0 28x1,5 mm; Manufacturer: DDS; Ins thickness: ins= 0.000000 mm; Outside dimension: 28.000000; Layer number: 198; Main string number: 00; Project name: OpenBIM; Height: 0; Insulation k-value: 0; Pressure drop: 0; Insulation WSVO: 0; Flow (m\X\B3/h): 0.0 m\X\B3/h; Product Number: BE3000028090; Width: 25; Medium: Gas middle pressure; Flow (l/h): 0.000000 l/h; Length: 90.0 m; Part number: .000; Sub string number: .0000; Dimension DN: 25 mm; Building Part: Building: 0; Flow (l/s): 0.00 l/s; Pipe thickness:: x1.5; Abs. pressure: 0.0 Pa; Velocity: 0.00 m/s
AC_Pset_RenovationAndPhasing - Renovation Status: Existing
Name | In | Mtg. Above Slab ref Bottom | Mounting Height | Above Sea Level ref. Bottom | Y | Mtg. above Finished Floor ref Center | Rotation | Mtg. Above Slab ref Center | Mtg. Below Ceiling ref Center | Above Sea Level ref. Center | Model Number | Floor number | X | Mtg. Below Ceiling ref Top | Room number | Room tekst
Bend | -01 Foundation | Edge= -0.01m SSL | 0.00 m | NNUK=-1.02 m | Y=11.21 | CC= 0.00m FFB | 270.000000 | CC= 0.00m SSL | CC= 0.67m FCL | NN=-1.00 m | Dra.no: 0 | Storey: 1 | X=30.24 | Top= 0.00m FCL
Bend | 00 Ground floor | Edge= 0.36m SSL | 0.50 m | NNUK=0.28 m | Y=10.94 | CC= 0.37m FFB | 270.000000 | CC= 0.37m SSL | CC= 2.93m FCL | NN=0.30 m | Dra.no: 1 | Storey: 2 | X=30.97 | Top= 2.92m FCL | 00.27 | Shaft
Bend | 00 Ground floor | Edge= 0.36m SSL | 0.50 m | NNUK=0.28 m | Y=10.62 | CC= 0.37m FFB | 180.000000 | CC= 0.37m SSL | CC= 2.93m FCL | NN=0.30 m | Dra.no: 1 | Storey: 2 | X=30.97 | Top= 2.92m FCL | 00.15 | FB
Bend | 00 Ground floor | Edge= 0.36m SSL | 0.50 m | NNUK=0.28 m | Y=10.62 | CC= 0.37m FFB | 180.000000 | CC= 0.37m SSL | CC= 2.93m FCL | NN=0.30 m | Dra.no: 1 | Storey: 2 | X=30.24 | Top= 2.92m FCL | 00.15 | FB
Bend | 00 Ground floor | Edge= 0.36m SSL | 0.50 m | NNUK=0.28 m | Y=11.21 | CC= 0.37m FFB | 270.000000 | CC= 0.37m SSL | CC= 2.93m FCL | NN=0.30 m | Dra.no: 1 | Storey: 2 | X=30.24 | Top= 2.92m FCL | 00.27 | Shaft
Bend | 02 Second floor | Edge= 0.26m SSL | 0.40 m | NNUK=7.18 m | Y=12.88 | CC= 0.27m FFB | 90.000000 | CC= 0.27m SSL | CC= 3.03m FCL | NN=7.20 m | Dra.no: 3 | Storey: 4 | X=8.03 | Top= 3.02m FCL | 02.04 | Installation space
Bend | 02 Second floor | Edge= 2.79m SSL | 2.80 m | NNUK=9.58 m | Y=10.94 | CC= 2.80m FFB | 270.000002 | CC= 2.80m SSL | CC= 0.50m FCL | NN=9.60 m | Dra.no: 3 | Storey: 4 | X=30.97 | Top= 0.00m FCL
Bend | 02 Second floor | Edge= 2.66m SSL | 2.80 m | NNUK=9.58 m | Y=10.94 | CC= 2.67m FFB | 0.000000 | CC= 2.67m SSL | CC= 0.63m FCL | NN=9.60 m | Dra.no: 3 | Storey: 4 | X=8.13 | Top= 0.62m FCL | 02.04 | Installation space
Bend | 02 Second floor | Edge= 2.66m SSL | 2.80 m | NNUK=9.58 m | Y=11.82 | CC= 2.67m FFB | 90.000000 | CC= 2.67m SSL | CC= 0.63m FCL | NN=9.60 m | Dra.no: 3 | Storey: 4 | X=8.13 | Top= 0.62m FCL | 02.04 | Installation space
Bend | 02 Second floor | Edge= 0.26m SSL | 0.40 m | NNUK=7.18 m | Y=11.82 | CC= 0.27m FFB | 270.000000 | CC= 0.27m SSL | CC= 3.03m FCL | NN=7.20 m | Dra.no: 3 | Storey: 4 | X=8.13 | Top= 3.02m FCL | 02.04 | Installation space
Bend | 02 Second floor | Edge= 0.26m SSL | 0.40 m | NNUK=7.18 m | Y=13.51 | CC= 0.27m FFB | 180.000000 | CC= 0.27m SSL | CC= 3.03m FCL | NN=7.20 m | Dra.no: 3 | Storey: 4 | X=8.13 | Top= 3.02m FCL | 02.04 | Installation space
Bend | 02 Second floor | Edge= 0.26m SSL | 0.40 m | NNUK=7.18 m | Y=13.51 | CC= 0.27m FFB | 270.000000 | CC= 0.27m SSL | CC= 3.03m FCL | NN=7.20 m | Dra.no: 3 | Storey: 4 | X=8.03 | Top= 3.02m FCL | 02.04 | Installation space
Bend | 02 Second floor | Edge= 0.26m SSL | 0.40 m | NNUK=7.18 m | Y=12.25 | CC= 0.27m FFB | 90.000000 | CC= 0.27m SSL | CC= 3.03m FCL | NN=7.20 m | Dra.no: 3 | Storey: 4 | X=8.03 | Top= 3.02m FCL | 02.04 | Installation space

# IfcFlowFitting: BE3000035090 (47)
Type - Description: Cu fitting bend 90\X\B0 35x1,5 mm; ApplicableOccurrence: Basic; PredefinedType: BEND
Type - Pset_ManufacturerTypeInformation - ArticleNumber: BE3000035090; ModelReference: Cu fitting bend 90\X\B0 35x1,5 mm; Manufacturer: DDS
Type - Pset_PipeFittingTypeCommon - SubType: Bend 90 degree; NominalDiameter: 32; InnerDiameter: 32; OuterDiameter: 35
Material: IFC Building Material
Pset_DDS - Manufacturer: DDS; Width: 32; Dimension DN: 32 mm; Project name: OpenBIM; Height: 0; Insulation k-value: 0; Pressure drop: 0; Flow (m\X\B3/h): 0.0 m\X\B3/h; Product Number: BE3000035090; Flow (l/h): 0.000000 l/h; Length: 90.0 m; Outside dimension: 35.000000; Product: Cu fitting bend 90\X\B0 35x1,5 mm; Building Part: Building: 0; Flow (l/s): 0.00 l/s; Pipe thickness:: x1.5; Abs. pressure: 0.0 Pa; Velocity: 0.00 m/s
AC_Pset_RenovationAndPhasing - Renovation Status: Existing
Name | In | Rotation | Mounting Height | Mtg. Below Ceiling ref Center | Mtg. Above Slab ref Bottom | Mtg. above Finished Floor ref Center | Main string number | Mtg. Above Slab ref Center | Ins thickness | Model Number | Layer number | X | Above Sea Level ref. Center | Insulation WSVO | Floor number | Y | Part number | Above Sea Level ref. Bottom | Sub string number | Medium | Mtg. Below Ceiling ref Top | Insulation product text | Insulation product number | Room number | Room tekst
2.1.0 | 00 Ground floor | 90.000000 | 2.80 m | CC= 0.70m FCL | Edge= 2.78m SSL | CC= 2.80m FFB | 02 | CC= 2.80m SSL | ins= 0.000000 mm | Dra.no: 1 | 188 | X=30.76 | NN=2.60 m | 0 | Storey: 2 | Y=13.25 | .000 | NNUK=2.57 m | .0001 | Cooling Flow | Top= 0.00m FCL | Pset_DDS - System Name: Cooling; Group: Cooling flow
3.1.0 | 00 Ground floor | 90.000000 | 2.80 m | CC= 0.70m FCL | Edge= 2.78m SSL | CC= 2.80m FFB | 03 | CC= 2.80m SSL | ins= 0.000000 mm | Dra.no: 1 | 189 | X=30.76 | NN=2.60 m | 0 | Storey: 2 | Y=13.18 | .000 | NNUK=2.57 m | .0001 | Cooling return | Top= 0.00m FCL | Pset_DDS - System Name: Cooling; Group: Cooling return
2.1.4 | 03. Roof | 90.000000 | 0.50 m | CC= 2.87m FCL | Edge= 0.48m SSL | CC= 0.50m FFB | 02 | CC= 0.50m SSL | ins= 9.000000 mm | Dra.no: 4 | 188 | X=30.76 | NN=10.80 m | 0 | Storey: 5 | Y=13.25 | .004 | NNUK=10.77 m | .0001 | Cooling Flow | Top= 0.00m FCL | Pipe insulation | ZP150/935 | Group: Cooling flow
3.1.7 | 03. Roof | 90.000000 | 0.50 m | CC= 2.87m FCL | Edge= 0.48m SSL | CC= 0.50m FFB | 03 | CC= 0.50m SSL | ins= 9.000000 mm | Dra.no: 4 | 189 | X=30.76 | NN=10.80 m | 0 | Storey: 5 | Y=13.18 | .007 | NNUK=10.77 m | .0001 | Cooling return | Top= 0.00m FCL | Pipe insulation | ZP150/935 | Group: Cooling return
Bend | 00 Ground floor | 0.000000 | -0.20 m | CC= 3.50m FCL | Edge= -0.22m SSL | CC= -0.20m FFB | 00 | CC= -0.20m SSL | ins= 0.000000 mm | Dra.no: 1 | 5 | X=6.18 | NN=-0.40 m | 0 | Storey: 2 | Y=10.84 | .000 | NNUK=-0.43 m | .0000 | Heat flow | Top= 3.48m FCL |  |  | 00.19 | Office
Bend | 00 Ground floor | 180.000000 | -0.20 m | CC= 3.50m FCL | Edge= -0.22m SSL | CC= -0.20m FFB | 00 | CC= -0.20m SSL | ins= 0.000000 mm | Dra.no: 1 | 5 | X=5.47 | NN=-0.40 m | 0 | Storey: 2 | Y=10.84 | .000 | NNUK=-0.43 m | .0000 | Heat flow | Top= 3.48m FCL |  |  | 00.19 | Office
Bend | 00 Ground floor | 180.000000 | -0.20 m | CC= 3.50m FCL | Edge= -0.22m SSL | CC= -0.20m FFB | 00 | CC= -0.20m SSL | ins= 0.000000 mm | Dra.no: 1 | 5 | X=5.47 | NN=-0.40 m | 0 | Storey: 2 | Y=22.09 | .000 | NNUK=-0.43 m | .0000 | Heat flow | Top= 3.48m FCL |  |  | 00.05 | Staircase
Bend | 00 Ground floor | 90.000000 | -0.10 m | CC= 3.53m FCL | Edge= -0.25m SSL | CC= -0.23m FFB | 00 | CC= -0.23m SSL | ins= 0.000000 mm | Dra.no: 1 | 6 | X=29.38 | NN=-0.30 m | 0 | Storey: 2 | Y=11.83 | .000 | NNUK=-0.33 m | .0000 | Heat return | Top= 3.51m FCL |  |  | 00.27 | Shaft
Bend | 00 Ground floor | 270.000000 | 0.09 m | CC= 3.21m FCL | Edge= 0.07m SSL | CC= 0.09m FFB | 00 | CC= 0.09m SSL | ins= 0.000000 mm | Dra.no: 1 | 5 | X=6.18 | NN=-0.11 m | 0 | Storey: 2 | Y=10.68 | .000 | NNUK=-0.14 m | .0000 | Heat flow | Top= 3.19m FCL |  |  | 00.19 | Office
Bend | 00 Ground floor | 270.000000 | 0.09 m | CC= 3.21m FCL | Edge= 0.07m SSL | CC= 0.09m FFB | 00 | CC= 0.09m SSL | ins= 0.000000 mm | Dra.no: 1 | 5 | X=6.18 | NN=-0.11 m | 0 | Storey: 2 | Y=10.55 | .000 | NNUK=-0.14 m | .0000 | Heat flow | Top= 3.19m FCL |  |  | 00.19 | Office
Bend | 00 Ground floor | 270.000000 | -0.20 m | CC= 3.50m FCL | Edge= -0.22m SSL | CC= -0.20m FFB | 00 | CC= -0.20m SSL | ins= 0.000000 mm | Dra.no: 1 | 5 | X=6.18 | NN=-0.40 m | 0 | Storey: 2 | Y=10.55 | .000 | NNUK=-0.43 m | .0000 | Heat flow | Top= 3.48m FCL |  |  | 00.19 | Office
Bend | 00 Ground floor | 90.000000 | -0.20 m | CC= 3.63m FCL | Edge= -0.35m SSL | CC= -0.33m FFB | 00 | CC= -0.33m SSL | ins= 0.000000 mm | Dra.no: 1 | 5 | X=29.38 | NN=-0.40 m | 0 | Storey: 2 | Y=11.94 | .000 | NNUK=-0.43 m | .0000 | Heat flow | Top= 3.61m FCL |  |  | 00.27 | Shaft
Bend | 00 Ground floor | 180.000000 | -0.10 m | CC= 3.40m FCL | Edge= -0.12m SSL | CC= -0.10m FFB | 00 | CC= -0.10m SSL | ins= 0.000000 mm | Dra.no: 1 | 6 | X=5.60 | NN=-0.30 m | 0 | Storey: 2 | Y=21.96 | .000 | NNUK=-0.33 m | .0000 | Heat return | Top= 3.38m FCL |  |  | 00.05 | Staircase
Bend | 00 Ground floor | 0.000000 | -0.10 m | CC= 3.40m FCL | Edge= -0.12m SSL | CC= -0.10m FFB | 00 | CC= -0.10m SSL | ins= 0.000000 mm | Dra.no: 1 | 6 | X=6.13 | NN=-0.30 m | 0 | Storey: 2 | Y=11.01 | .000 | NNUK=-0.33 m | .0000 | Heat return | Top= 3.38m FCL |  |  | 00.19 | Office
Bend | 00 Ground floor | 180.000000 | -0.10 m | CC= 3.40m FCL | Edge= -0.12m SSL | CC= -0.10m FFB | 00 | CC= -0.10m SSL | ins= 0.000000 mm | Dra.no: 1 | 6 | X=5.60 | NN=-0.30 m | 0 | Storey: 2 | Y=11.01 | .000 | NNUK=-0.33 m | .0000 | Heat return | Top= 3.38m FCL |  |  | 00.19 | Office
Bend | 00 Ground floor | 270.000000 | -0.10 m | CC= 3.40m FCL | Edge= -0.12m SSL | CC= -0.10m FFB | 00 | CC= -0.10m SSL | ins= 0.000000 mm | Dra.no: 1 | 6 | X=6.13 | NN=-0.30 m | 0 | Storey: 2 | Y=10.55 | .000 | NNUK=-0.33 m | .0000 | Heat return | Top= 3.38m FCL |  |  | 00.19 | Office
Bend | 00 Ground floor | 270.000000 | 0.09 m | CC= 3.21m FCL | Edge= 0.07m SSL | CC= 0.09m FFB | 00 | CC= 0.09m SSL | ins= 0.000000 mm | Dra.no: 1 | 6 | X=6.13 | NN=-0.11 m | 0 | Storey: 2 | Y=10.55 | .000 | NNUK=-0.14 m | .0000 | Heat return | Top= 3.19m FCL |  |  | 00.19 | Office
Bend | 00 Ground floor | 270.000000 | 0.09 m | CC= 3.21m FCL | Edge= 0.07m SSL | CC= 0.09m FFB | 00 | CC= 0.09m SSL | ins= 0.000000 mm | Dra.no: 1 | 6 | X=6.13 | NN=-0.11 m | 0 | Storey: 2 | Y=10.68 | .000 | NNUK=-0.14 m | .0000 | Heat return | Top= 3.19m FCL |  |  | 00.19 | Office
Bend | 02 Second floor | 180.000000 | 2.60 m | CC= 0.83m FCL | Edge= 2.45m SSL | CC= 2.47m FFB | 00 | CC= 2.47m SSL | ins= 30.000000 mm | Dra.no: 3 | 5 | X=28.15 | NN=9.40 m | 100 | Storey: 4 | Y=11.33 | .000 | NNUK=9.37 m | .0000 | Heat flow | Top= 0.81m FCL | Fibre plastic covered | MK032100 | 02.03 | Unnamed
Bend | 02 Second floor | 0.000000 | 2.60 m | CC= 0.83m FCL | Edge= 2.45m SSL | CC= 2.47m FFB | 00 | CC= 2.47m SSL | ins= 30.000000 mm | Dra.no: 3 | 5 | X=28.15 | NN=9.40 m | 100 | Storey: 4 | Y=11.94 | .000 | NNUK=9.37 m | .0000 | Heat flow | Top= 0.81m FCL | Fibre plastic covered | MK032100 | 02.03 | Unnamed
