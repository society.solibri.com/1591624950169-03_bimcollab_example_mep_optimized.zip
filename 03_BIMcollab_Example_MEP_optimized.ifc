Properties of the parts of a building model (IFC2X3), part 12 of 14

# IfcFlowSegment: SS091209005 (88)
Name | In | Material | Mtg. Above Slab ref Bottom | Mounting Height | Above Sea Level ref. Bottom | Flow (l/h) | Main string number | Mtg. above Finished Floor ref Center | Pressure drop | Ins thickness | Mtg. Above Slab ref Center | Mtg. Below Ceiling ref Center | Above Sea Level ref. Center | Model Number | Layer number | Pset_DDS, Length | X | Floor number | Velocity | Part number | Peak flow (l/s) | Sub string number | Flow (l/s) | Medium | Y | Mtg. Below Ceiling ref Top | Abs. pressure | Pset_FlowSegmentPipeSegment, Length (mm) | Room number | Room tekst
Pipe | 00 Ground floor | ML-Copper pipes length 5 m 22x1 mm | Edge= -0.05m SSL | 0.09 m | NNUK=-0.12 m | 0.000000 l/h | 00 | CC= -0.04m FFB | 0 Pa | ins= 0.000000 mm | CC= -0.04m SSL | CC= 3.34m FCL | NN=-0.11 m | Dra.no: 1 | 6 | 0 | X=34.57 | Storey: 2 | 0.00 m/s | .000 | 0.00 l/s | .0000 | 0.00 l/s | Heat return | Y=6.98 | Top= 3.33m FCL | 0.0 Pa | 53.0373 | 00.25 | Director office
Pipe | 00 Ground floor | ML-Copper pipes length 5 m 22x1 mm | Edge= -0.21m SSL | -0.07 m | NNUK=-0.28 m | 0.000000 l/h | 00 | CC= -0.20m FFB | 0 Pa | ins= 0.000000 mm | CC= -0.20m SSL | CC= 3.50m FCL | NN=-0.27 m | Dra.no: 1 | 6 | 0 | X=34.57 | Storey: 2 | 0.00 m/s | .000 | 0.00 l/s | .0000 | 0.00 l/s | Heat return | Y=6.95 | Top= 3.49m FCL | 0.0 Pa | 130 | 00.25 | Director office
Pipe | 00 Ground floor | ML-Copper pipes length 5 m 22x1 mm | Edge= -0.24m SSL | -0.10 m | NNUK=-0.31 m | 0.000000 l/h | 00 | CC= -0.23m FFB | 0 Pa | ins= 0.000000 mm | CC= -0.23m SSL | CC= 3.53m FCL | NN=-0.30 m | Dra.no: 1 | 6 | 0 | X=34.57 | Storey: 2 | 0.00 m/s | .000 | 0.00 l/s | .0000 | 0.00 l/s | Heat return | Y=7.24 | Top= 3.52m FCL | 0.0 Pa | 261.699 | 00.25 | Director office
Pipe | 00 Ground floor | ML-Copper pipes length 5 m 22x1 mm | Edge= 0.01m SSL | -0.10 m | NNUK=-0.31 m | 0.000000 l/h | 00 | CC= 0.02m FFB | 0 Pa | ins= 0.000000 mm | CC= 0.02m SSL | CC= 3.28m FCL | NN=-0.30 m | Dra.no: 1 | 6 | 4 | X=38.29 | Storey: 2 | 0.00 m/s | .000 | 0.00 l/s | .0000 | 0.00 l/s | Heat return | Y=7.27 | Top= 3.27m FCL | 0.0 Pa | 3693.56 | 00.24 | Director office
Pipe | 01 First floor | ML-Copper pipes length 5 m 22x1 mm | Edge= -0.24m SSL | -0.10 m | NNUK=3.19 m | 0.000000 l/h | 00 | CC= -0.23m FFB | 0 Pa | ins= 0.000000 mm | CC= -0.23m SSL | CC= 3.53m FCL | NN=3.20 m | Dra.no: 2 | 5 | -0 | X=5.48 | Storey: 3 | 0.00 m/s | .000 | 0.00 l/s | .0000 | 0.00 l/s | Heat flow | Y=12.22 | Top= 3.52m FCL | 0.0 Pa | 5.45199 | 01.17 | Office
Pipe | 01 First floor | ML-Copper pipes length 5 m 22x1 mm | Edge= -0.24m SSL | -0.10 m | NNUK=3.19 m | 0.000000 l/h | 00 | CC= -0.23m FFB | 0 Pa | ins= 0.000000 mm | CC= -0.23m SSL | CC= 3.53m FCL | NN=3.20 m | Dra.no: 2 | 5 | 2 | X=5.51 | Storey: 3 | 0.00 m/s | .000 | 0.00 l/s | .0000 | 0.00 l/s | Heat flow | Y=14.41 | Top= 3.52m FCL | 0.0 Pa | 2157.26 | 01.17 | Office
Pipe | 01 First floor | ML-Copper pipes length 5 m 22x1 mm | Edge= -0.24m SSL | -0.10 m | NNUK=3.19 m | 0.000000 l/h | 00 | CC= -0.23m FFB | 0 Pa | ins= 0.000000 mm | CC= -0.23m SSL | CC= 3.53m FCL | NN=3.20 m | Dra.no: 2 | 5 | 8 | X=5.51 | Storey: 3 | 0.00 m/s | .000 | 0.00 l/s | .0000 | 0.00 l/s | Heat flow | Y=22.15 | Top= 3.52m FCL | 0.0 Pa | 7716.25 | 01.05 | Staircase
Pipe | 01 First floor | ML-Copper pipes length 5 m 22x1 mm | Edge= -0.24m SSL | -0.10 m | NNUK=3.19 m | 0.000000 l/h | 00 | CC= -0.23m FFB | 0 Pa | ins= 0.000000 mm | CC= -0.23m SSL | CC= 3.53m FCL | NN=3.20 m | Dra.no: 2 | 5 | 2 | X=7.31 | Storey: 3 | 0.00 m/s | .000 | 0.00 l/s | .0000 | 0.00 l/s | Heat flow | Y=22.18 | Top= 3.52m FCL | 0.0 Pa | 1768.18 | 01.05 | Staircase
Pipe | 01 First floor | ML-Copper pipes length 5 m 22x1 mm | Edge= 0.01m SSL | -0.10 m | NNUK=3.19 m | 0.000000 l/h | 00 | CC= 0.02m FFB | 0 Pa | ins= 0.000000 mm | CC= 0.02m SSL | CC= 3.28m FCL | NN=3.20 m | Dra.no: 2 | 5 | 4 | X=11.51 | Storey: 3 | 0.00 m/s | .000 | 0.00 l/s | .0000 | 0.00 l/s | Heat flow | Y=22.18 | Top= 3.27m FCL | 0.0 Pa | 4178 | 01.18 | Office
Pipe | 01 First floor | ML-Copper pipes length 5 m 22x1 mm | Edge= 0.01m SSL | -0.10 m | NNUK=3.19 m | 0.000000 l/h | 00 | CC= 0.02m FFB | 0 Pa | ins= 0.000000 mm | CC= 0.02m SSL | CC= 3.28m FCL | NN=3.20 m | Dra.no: 2 | 5 | 4 | X=16.01 | Storey: 3 | 0.00 m/s | .000 | 0.00 l/s | .0000 | 0.00 l/s | Heat flow | Y=22.18 | Top= 3.27m FCL | 0.0 Pa | 4478 | 01.20 | Office
Pipe | 01 First floor | ML-Copper pipes length 5 m 22x1 mm | Edge= 0.01m SSL | -0.10 m | NNUK=3.19 m | 0.000000 l/h | 00 | CC= 0.02m FFB | 0 Pa | ins= 0.000000 mm | CC= 0.02m SSL | CC= 3.28m FCL | NN=3.20 m | Dra.no: 2 | 5 | 2 | X=18.26 | Storey: 3 | 0.00 m/s | .000 | 0.00 l/s | .0000 | 0.00 l/s | Heat flow | Y=22.18 | Top= 3.27m FCL | 0.0 Pa | 2228 | 01.19 | Office
Pipe | 01 First floor | ML-Copper pipes length 5 m 22x1 mm | Edge= 0.01m SSL | -0.10 m | NNUK=3.19 m | 0.000000 l/h | 00 | CC= 0.02m FFB | 0 Pa | ins= 0.000000 mm | CC= 0.02m SSL | CC= 3.28m FCL | NN=3.20 m | Dra.no: 2 | 5 | 5 | X=22.81 | Storey: 3 | 0.00 m/s | .000 | 0.00 l/s | .0000 | 0.00 l/s | Heat flow | Y=22.18 | Top= 3.27m FCL | 0.0 Pa | 4528 | 01.13 | Storage
Pipe | 01 First floor | ML-Copper pipes length 5 m 22x1 mm | Edge= -0.24m SSL | -0.10 m | NNUK=3.19 m | 0.000000 l/h | 00 | CC= -0.23m FFB | 0 Pa | ins= 0.000000 mm | CC= -0.23m SSL | CC= 3.53m FCL | NN=3.20 m | Dra.no: 2 | 5 | 2 | X=25.26 | Storey: 3 | 0.00 m/s | .000 | 0.00 l/s | .0000 | 0.00 l/s | Heat flow | Y=22.18 | Top= 3.52m FCL | 0.0 Pa | 2428 | 01.02 | Hallway
Pipe | 01 First floor | ML-Copper pipes length 5 m 22x1 mm | Edge= -0.31m SSL | -0.17 m | NNUK=3.12 m | 0.000000 l/h | 00 | CC= -0.30m FFB | 0 Pa | ins= 0.000000 mm | CC= -0.30m SSL | CC= 3.60m FCL | NN=3.13 m | Dra.no: 2 | 6 | 0 | X=30.32 | Storey: 3 | 0.00 m/s | .000 | 0.00 l/s | .0000 | 0.00 l/s | Heat return | Y=22.40 | Top= 3.59m FCL | 0.0 Pa | 230 | 01.02 | Hallway
Pipe | 01 First floor | ML-Copper pipes length 5 m 22x1 mm | Edge= -0.05m SSL | 0.09 m | NNUK=3.38 m | 0.000000 l/h | 00 | CC= -0.04m FFB | 0 Pa | ins= 0.000000 mm | CC= -0.04m SSL | CC= 3.34m FCL | NN=3.39 m | Dra.no: 2 | 6 | 0 | X=30.32 | Storey: 3 | 0.00 m/s | .000 | 0.00 l/s | .0000 | 0.00 l/s | Heat return | Y=22.37 | Top= 3.33m FCL | 0.0 Pa | 53.0373 | 01.02 | Hallway
Pipe | 01 First floor | ML-Copper pipes length 5 m 22x1 mm | Edge= -0.34m SSL | -0.20 m | NNUK=3.09 m | 0.000000 l/h | 00 | CC= -0.33m FFB | 0 Pa | ins= 0.000000 mm | CC= -0.33m SSL | CC= 3.63m FCL | NN=3.10 m | Dra.no: 2 | 6 | 0 | X=30.32 | Storey: 3 | 0.00 m/s | .000 | 0.00 l/s | .0000 | 0.00 l/s | Heat return | Y=22.09 | Top= 3.62m FCL | 0.0 Pa | 284.415 | 01.02 | Hallway
Pipe | 01 First floor | ML-Copper pipes length 5 m 22x1 mm | Edge= -0.34m SSL | -0.20 m | NNUK=3.09 m | 0.000000 l/h | 00 | CC= -0.33m FFB | 0 Pa | ins= 0.000000 mm | CC= -0.33m SSL | CC= 3.63m FCL | NN=3.10 m | Dra.no: 2 | 6 | 0 | X=25.48 | Storey: 3 | 0.00 m/s | .000 | 0.00 l/s | .0000 | 0.00 l/s | Heat return | Y=22.06 | Top= 3.62m FCL | 0.0 Pa | 147.868 | 01.02 | Hallway
Pipe | 01 First floor | ML-Copper pipes length 5 m 22x1 mm | Edge= -0.34m SSL | -0.20 m | NNUK=3.09 m | 0.000000 l/h | 00 | CC= -0.33m FFB | 0 Pa | ins= 0.000000 mm | CC= -0.33m SSL | CC= 3.63m FCL | NN=3.10 m | Dra.no: 2 | 6 | 3 | X=27.58 | Storey: 3 | 0.00 m/s | .000 | 0.00 l/s | .0000 | 0.00 l/s | Heat return | Y=22.06 | Top= 3.62m FCL | 0.0 Pa | 2709 | 01.02 | Hallway
Pipe | 01 First floor | ML-Copper pipes length 5 m 22x1 mm | Edge= -0.34m SSL | -0.20 m | NNUK=3.09 m | 0.000000 l/h | 00 | CC= -0.33m FFB | 0 Pa | ins= 0.000000 mm | CC= -0.33m SSL | CC= 3.63m FCL | NN=3.10 m | Dra.no: 2 | 6 | 2 | X=25.31 | Storey: 3 | 0.00 m/s | .000 | 0.00 l/s | .0000 | 0.00 l/s | Heat return | Y=22.06 | Top= 3.62m FCL | 0.0 Pa | 2428 | 01.02 | Hallway
Pipe | 01 First floor | ML-Copper pipes length 5 m 22x1 mm | Edge= -0.34m SSL | -0.20 m | NNUK=3.09 m | 0.000000 l/h | 00 | CC= -0.33m FFB | 0 Pa | ins= 0.000000 mm | CC= -0.33m SSL | CC= 3.63m FCL | NN=3.10 m | Dra.no: 2 | 6 | 2 | X=25.51 | Storey: 3 | 0.00 m/s | .000 | 0.00 l/s | .0000 | 0.00 l/s | Heat return | Y=22.06 | Top= 3.62m FCL | 0.0 Pa | 2048.13 | 01.02 | Hallway
Pipe | 01 First floor | ML-Copper pipes length 5 m 22x1 mm | Edge= -0.09m SSL | -0.20 m | NNUK=3.09 m | 0.000000 l/h | 00 | CC= -0.08m FFB | 0 Pa | ins= 0.000000 mm | CC= -0.08m SSL | CC= 3.38m FCL | NN=3.10 m | Dra.no: 2 | 6 | 5 | X=22.86 | Storey: 3 | 0.00 m/s | .000 | 0.00 l/s | .0000 | 0.00 l/s | Heat return | Y=22.06 | Top= 3.37m FCL | 0.0 Pa | 4528 | 01.13 | Storage
Pipe | 01 First floor | ML-Copper pipes length 5 m 22x1 mm | Edge= -0.34m SSL | -0.20 m | NNUK=3.09 m | 0.000000 l/h | 00 | CC= -0.33m FFB | 0 Pa | ins= 0.000000 mm | CC= -0.33m SSL | CC= 3.63m FCL | NN=3.10 m | Dra.no: 2 | 6 | 10 | X=25.50 | Storey: 3 | 0.00 m/s | .000 | 0.00 l/s | .0000 | 0.00 l/s | Heat return | Y=11.67 | Top= 3.62m FCL | 0.0 Pa | 10379.4 | 01.03 | Restaurant
Pipe | 01 First floor | ML-Copper pipes length 5 m 22x1 mm | Edge= -0.09m SSL | -0.20 m | NNUK=3.09 m | 0.000000 l/h | 00 | CC= -0.08m FFB | 0 Pa | ins= 0.000000 mm | CC= -0.08m SSL | CC= 3.38m FCL | NN=3.10 m | Dra.no: 2 | 6 | 2 | X=18.31 | Storey: 3 | 0.00 m/s | .000 | 0.00 l/s | .0000 | 0.00 l/s | Heat return | Y=22.06 | Top= 3.37m FCL | 0.0 Pa | 2228 | 01.19 | Office
Pipe | 01 First floor | ML-Copper pipes length 5 m 22x1 mm | Edge= -0.34m SSL | -0.20 m | NNUK=3.09 m | 0.000000 l/h | 00 | CC= -0.33m FFB | 0 Pa | ins= 0.000000 mm | CC= -0.33m SSL | CC= 3.63m FCL | NN=3.10 m | Dra.no: 2 | 6 | 1 | X=26.29 | Storey: 3 | 0.00 m/s | .000 | 0.00 l/s | .0000 | 0.00 l/s | Heat return | Y=11.64 | Top= 3.62m FCL | 0.0 Pa | 758.041 | 01.03 | Restaurant
Pipe | 01 First floor | ML-Copper pipes length 5 m 22x1 mm | Edge= -0.09m SSL | -0.20 m | NNUK=3.09 m | 0.000000 l/h | 00 | CC= -0.08m FFB | 0 Pa | ins= 0.000000 mm | CC= -0.08m SSL | CC= 3.38m FCL | NN=3.10 m | Dra.no: 2 | 6 | 4 | X=16.06 | Storey: 3 | 0.00 m/s | .000 | 0.00 l/s | .0000 | 0.00 l/s | Heat return | Y=22.06 | Top= 3.37m FCL | 0.0 Pa | 4478 | 01.20 | Office
Pipe | 01 First floor | ML-Copper pipes length 5 m 22x1 mm | Edge= -0.34m SSL | -0.20 m | NNUK=3.09 m | 0.000000 l/h | 00 | CC= -0.33m FFB | 0 Pa | ins= 0.000000 mm | CC= -0.33m SSL | CC= 3.63m FCL | NN=3.10 m | Dra.no: 2 | 6 | 0 | X=26.32 | Storey: 3 | 0.00 m/s | .000 | 0.00 l/s | .0000 | 0.00 l/s | Heat return | Y=11.80 | Top= 3.62m FCL | 0.0 Pa | 139.351 | 01.03 | Restaurant
Pipe | 01 First floor | ML-Copper pipes length 5 m 22x1 mm | Edge= -0.09m SSL | -0.20 m | NNUK=3.09 m | 0.000000 l/h | 00 | CC= -0.08m FFB | 0 Pa | ins= 0.000000 mm | CC= -0.08m SSL | CC= 3.38m FCL | NN=3.10 m | Dra.no: 2 | 6 | 4 | X=11.56 | Storey: 3 | 0.00 m/s | .000 | 0.00 l/s | .0000 | 0.00 l/s | Heat return | Y=22.06 | Top= 3.37m FCL | 0.0 Pa | 4178 | 01.18 | Office
Pipe | 01 First floor | ML-Copper pipes length 5 m 22x1 mm | Edge= -0.21m SSL | -0.20 m | NNUK=3.09 m | 0.000000 l/h | 00 | CC= -0.20m FFB | 0 Pa | ins= 0.000000 mm | CC= -0.20m SSL | CC= 3.50m FCL | NN=3.10 m | Dra.no: 2 | 6 | 3 | X=29.36 | Storey: 3 | 0.00 m/s | .000 | 0.00 l/s | .0000 | 0.00 l/s | Heat return | Y=11.83 | Top= 0.00m FCL | 0.0 Pa | 3012.89
Pipe | 01 First floor | ML-Copper pipes length 5 m 22x1 mm | Edge= -0.34m SSL | -0.20 m | NNUK=3.09 m | 0.000000 l/h | 00 | CC= -0.33m FFB | 0 Pa | ins= 0.000000 mm | CC= -0.33m SSL | CC= 3.63m FCL | NN=3.10 m | Dra.no: 2 | 6 | 2 | X=7.36 | Storey: 3 | 0.00 m/s | .000 | 0.00 l/s | .0000 | 0.00 l/s | Heat return | Y=22.06 | Top= 3.62m FCL | 0.0 Pa | 1678.69 | 01.05 | Staircase
Pipe | 01 First floor | ML-Copper pipes length 5 m 22x1 mm | Edge= -0.34m SSL | -0.20 m | NNUK=3.09 m | 0.000000 l/h | 00 | CC= -0.33m FFB | 0 Pa | ins= 0.000000 mm | CC= -0.33m SSL | CC= 3.63m FCL | NN=3.10 m | Dra.no: 2 | 6 | 8 | X=5.65 | Storey: 3 | 0.00 m/s | .000 | 0.00 l/s | .0000 | 0.00 l/s | Heat return | Y=22.03 | Top= 3.62m FCL | 0.0 Pa | 7551.76 | 01.05 | Staircase
Pipe | 01 First floor | ML-Copper pipes length 5 m 22x1 mm | Edge= -0.34m SSL | -0.20 m | NNUK=3.09 m | 0.000000 l/h | 00 | CC= -0.33m FFB | 0 Pa | ins= 0.000000 mm | CC= -0.33m SSL | CC= 3.63m FCL | NN=3.10 m | Dra.no: 2 | 6 | 2 | X=5.65 | Storey: 3 | 0.00 m/s | .000 | 0.00 l/s | .0000 | 0.00 l/s | Heat return | Y=14.46 | Top= 3.62m FCL | 0.0 Pa | 2157.26 | 01.17 | Office
Pipe | 01 First floor | ML-Copper pipes length 5 m 22x1 mm | Edge= -0.34m SSL | -0.20 m | NNUK=3.09 m | 0.000000 l/h | 00 | CC= -0.33m FFB | 0 Pa | ins= 0.000000 mm | CC= -0.33m SSL | CC= 3.63m FCL | NN=3.10 m | Dra.no: 2 | 6 | -0 | X=5.62 | Storey: 3 | 0.00 m/s | .000 | 0.00 l/s | .0000 | 0.00 l/s | Heat return | Y=12.27 | Top= 3.62m FCL | 0.0 Pa | 5.45199 | 01.17 | Office
Pipe | 01 First floor | ML-Copper pipes length 5 m 22x1 mm | Edge= -0.24m SSL | -0.10 m | NNUK=3.19 m | 0.000000 l/h | 00 | CC= -0.23m FFB | 0 Pa | ins= 0.000000 mm | CC= -0.23m SSL | CC= 3.53m FCL | NN=3.20 m | Dra.no: 2 | 5 | 0 | X=25.58 | Storey: 3 | 0.00 m/s | .000 | 0.00 l/s | .0000 | 0.00 l/s | Heat flow | Y=22.18 | Top= 3.52m FCL | 0.0 Pa | 300 | 01.02 | Hallway
Pipe | 01 First floor | ML-Copper pipes length 5 m 22x1 mm | Edge= -0.05m SSL | 0.09 m | NNUK=3.38 m | 0.000000 l/h | 00 | CC= -0.04m FFB | 0 Pa | ins= 0.000000 mm | CC= -0.04m SSL | CC= 3.34m FCL | NN=3.39 m | Dra.no: 2 | 5 | 0 | X=30.27 | Storey: 3 | 0.00 m/s | .000 | 0.00 l/s | .0000 | 0.00 l/s | Heat flow | Y=22.37 | Top= 3.33m FCL | 0.0 Pa | 53.0373 | 01.02 | Hallway
Pipe | 01 First floor | ML-Copper pipes length 5 m 22x1 mm | Edge= -0.21m SSL | -0.07 m | NNUK=3.22 m | 0.000000 l/h | 00 | CC= -0.20m FFB | 0 Pa | ins= 0.000000 mm | CC= -0.20m SSL | CC= 3.50m FCL | NN=3.23 m | Dra.no: 2 | 5 | 0 | X=30.27 | Storey: 3 | 0.00 m/s | .000 | 0.00 l/s | .0000 | 0.00 l/s | Heat flow | Y=22.40 | Top= 3.49m FCL | 0.0 Pa | 130 | 01.02 | Hallway
Pipe | 01 First floor | ML-Copper pipes length 5 m 22x1 mm | Edge= -0.24m SSL | -0.10 m | NNUK=3.19 m | 0.000000 l/h | 00 | CC= -0.23m FFB | 0 Pa | ins= 0.000000 mm | CC= -0.23m SSL | CC= 3.53m FCL | NN=3.20 m | Dra.no: 2 | 5 | 0 | X=30.27 | Storey: 3 | 0.00 m/s | .000 | 0.00 l/s | .0000 | 0.00 l/s | Heat flow | Y=22.21 | Top= 3.52m FCL | 0.0 Pa | 169.929 | 01.02 | Hallway
Pipe | 01 First floor | ML-Copper pipes length 5 m 22x1 mm | Edge= -0.24m SSL | -0.10 m | NNUK=3.19 m | 0.000000 l/h | 00 | CC= -0.23m FFB | 0 Pa | ins= 0.000000 mm | CC= -0.23m SSL | CC= 3.53m FCL | NN=3.20 m | Dra.no: 2 | 5 | 3 | X=27.53 | Storey: 3 | 0.00 m/s | .000 | 0.00 l/s | .0000 | 0.00 l/s | Heat flow | Y=22.18 | Top= 3.52m FCL | 0.0 Pa | 2709 | 01.02 | Hallway
Pipe | 01 First floor | ML-Copper pipes length 5 m 22x1 mm | Edge= -0.24m SSL | -0.10 m | NNUK=3.19 m | 0.000000 l/h | 00 | CC= -0.23m FFB | 0 Pa | ins= 0.000000 mm | CC= -0.23m SSL | CC= 3.53m FCL | NN=3.20 m | Dra.no: 2 | 5 | 2 | X=25.62 | Storey: 3 | 0.00 m/s | .000 | 0.00 l/s | .0000 | 0.00 l/s | Heat flow | Y=22.18 | Top= 3.52m FCL | 0.0 Pa | 1896.18 | 01.02 | Hallway
Pipe | 01 First floor | ML-Copper pipes length 5 m 22x1 mm | Edge= -0.24m SSL | -0.10 m | NNUK=3.19 m | 0.000000 l/h | 00 | CC= -0.23m FFB | 0 Pa | ins= 0.000000 mm | CC= -0.23m SSL | CC= 3.53m FCL | NN=3.20 m | Dra.no: 2 | 5 | 10 | X=25.60 | Storey: 3 | 0.00 m/s | .000 | 0.00 l/s | .0000 | 0.00 l/s | Heat flow | Y=11.76 | Top= 3.52m FCL | 0.0 Pa | 10399.9 | 01.03 | Restaurant
Pipe | 01 First floor | ML-Copper pipes length 5 m 22x1 mm | Edge= -0.24m SSL | -0.10 m | NNUK=3.19 m | 0.000000 l/h | 00 | CC= -0.23m FFB | 0 Pa | ins= 0.000000 mm | CC= -0.23m SSL | CC= 3.53m FCL | NN=3.20 m | Dra.no: 2 | 5 | 0 | X=26.21 | Storey: 3 | 0.00 m/s | .000 | 0.00 l/s | .0000 | 0.00 l/s | Heat flow | Y=11.91 | Top= 3.52m FCL | 0.0 Pa | 153.244 | 01.03 | Restaurant
Pipe | 01 First floor | ML-Copper pipes length 5 m 22x1 mm | Edge= -0.11m SSL | -0.10 m | NNUK=3.19 m | 0.000000 l/h | 00 | CC= -0.10m FFB | 0 Pa | ins= 0.000000 mm | CC= -0.10m SSL | CC= 3.40m FCL | NN=3.20 m | Dra.no: 2 | 5 | 3 | X=29.36 | Storey: 3 | 0.00 m/s | .000 | 0.00 l/s | .0000 | 0.00 l/s | Heat flow | Y=11.94 | Top= 0.00m FCL | 0.0 Pa | 3119.06
Pipe | 01 First floor | ML-Copper pipes length 5 m 22x1 mm | Edge= -0.24m SSL | -0.10 m | NNUK=3.19 m | 0.000000 l/h | 00 | CC= -0.23m FFB | 0 Pa | ins= 0.000000 mm | CC= -0.23m SSL | CC= 3.53m FCL | NN=3.20 m | Dra.no: 2 | 5 | 1 | X=26.18 | Storey: 3 | 0.00 m/s | .000 | 0.00 l/s | .0000 | 0.00 l/s | Heat flow | Y=11.73 | Top= 3.52m FCL | 0.0 Pa | 549.921 | 01.03 | Restaurant

# IfcFlowSegment: SS091209006 (24)
Type - Description: Copper pipes length 5 m 28x1,5 mm; ApplicableOccurrence: Copper; PredefinedType: RIGIDSEGMENT
Type - Pset_ManufacturerTypeInformation - ArticleNumber: SS091209006; ModelReference: Copper pipes length 5 m 28x1,5 mm; Manufacturer: DDS
Type - Pset_PipeSegmentTypeCommon - NominalDiameter: 25; InnerDiameter: 25; OuterDiameter: 28
Material: ML-Copper pipes length 5 m 28x1,5 mm
Pset_DDS - Pressure drop: 0 Pa; Drain slope: 1:0; Manufacturer: DDS; Ins thickness: ins= 0.000000 mm; Outside dimension: 28.000000; Layer number: 198; Drain slope (%): 10000.0 %; Main string number: 00; Project name: OpenBIM; Insulation WSVO: 0; Insulation k-value: 0; Drain Qww: Qww=0.00 l/s; Product: Copper pipes length 5 m 28x1,5 mm; Width: 25; Dimension DN: 25; Medium: Gas middle pressure; Flow (l/h): 0.000000 l/h; Sub string number: .0000; Drain slope (\X\B0): 90.0\X\B0; Temperature: 0.00 \X\B0C; Drain DU: DU=0.00 l/s; Product Number: SS091209006; Building Part: Building: 0; Peak flow (l/s): 0.00 l/s; Flow (l/s): 0.00 l/s; Flowsegment thickness: x1.5; Abs. pressure: 0.0 Pa; Velocity: 0.00 m/s
AC_Pset_RenovationAndPhasing - Renovation Status: Existing
Name | In | Pset_FlowSegmentPipeSegment, Length (mm) | Mtg. Above Slab ref Bottom | Mounting Height | Mtg. above Finished Floor ref Center | Mtg. Above Slab ref Center | Mtg. Below Ceiling ref Center | Above Sea Level ref. Center | Above Sea Level ref. Bottom | Model Number | Pset_DDS, Length | Floor number | X | Part number | Y | Mtg. Below Ceiling ref Top | Room number | Room tekst
Pipe | -01 Foundation | 10140.8 | Edge= -0.01m SSL | 0.00 m | CC= 0.00m FFB | CC= 0.00m SSL | CC= 0.67m FCL | NN=-1.00 m | NNUK=-1.01 m | Dra.no: 0 | 10 | Storey: 1 | X=30.24 | .025 | Y=1.03 | Top= 0.00m FCL
Pipe | -01 Foundation | 712.5 | Edge= 0.02m SSL | 0.04 m | CC= 0.04m FFB | CC= 0.04m SSL | CC= 0.63m FCL | NN=-0.96 m | NNUK=-0.97 m | Dra.no: 0 | 1 | Storey: 1 | X=30.24 | .000 | Y=11.21 | Top= 0.00m FCL
Pipe | 00 Ground floor | 2912.5 | Edge= 0.40m SSL | 0.54 m | CC= 0.41m FFB | CC= 0.41m SSL | CC= 2.89m FCL | NN=0.34 m | NNUK=0.33 m | Dra.no: 1 | 3 | Storey: 2 | X=30.97 | .000 | Y=10.94 | Top= 2.88m FCL | 00.27 | Shaft
Pipe | 00 Ground floor | 243.683 | Edge= 0.36m SSL | 0.50 m | CC= 0.37m FFB | CC= 0.37m SSL | CC= 2.93m FCL | NN=0.30 m | NNUK=0.29 m | Dra.no: 1 | 0 | Storey: 2 | X=30.97 | .000 | Y=10.66 | Top= 2.92m FCL | 00.15 | FB
Pipe | 00 Ground floor | 89.1596 | Edge= 0.36m SSL | 0.50 m | CC= 0.37m FFB | CC= 0.37m SSL | CC= 2.93m FCL | NN=0.30 m | NNUK=0.29 m | Dra.no: 1 | 0 | Storey: 2 | X=30.84 | .000 | Y=10.62 | Top= 2.92m FCL | 00.15 | FB
Pipe | 00 Ground floor | 41 | Edge= 0.36m SSL | 0.50 m | CC= 0.37m FFB | CC= 0.37m SSL | CC= 2.93m FCL | NN=0.30 m | NNUK=0.29 m | Dra.no: 1 | 0 | Storey: 2 | X=30.71 | .000 | Y=10.62 | Top= 2.92m FCL | 00.15 | FB
Pipe | 00 Ground floor | 54.5379 | Edge= 0.36m SSL | 0.50 m | CC= 0.37m FFB | CC= 0.37m SSL | CC= 2.93m FCL | NN=0.30 m | NNUK=0.29 m | Dra.no: 1 | 0 | Storey: 2 | X=30.41 | .000 | Y=10.62 | Top= 2.92m FCL | 00.15 | FB
Pipe | 00 Ground floor | 42.943 | Edge= 0.36m SSL | 0.50 m | CC= 0.37m FFB | CC= 0.37m SSL | CC= 2.93m FCL | NN=0.30 m | NNUK=0.29 m | Dra.no: 1 | 0 | Storey: 2 | X=30.27 | .000 | Y=10.62 | Top= 2.92m FCL | 00.15 | FB
Pipe | 00 Ground floor | 513.436 | Edge= 0.36m SSL | 0.50 m | CC= 0.37m FFB | CC= 0.37m SSL | CC= 2.93m FCL | NN=0.30 m | NNUK=0.29 m | Dra.no: 1 | 1 | Storey: 2 | X=30.24 | .000 | Y=11.17 | Top= 2.92m FCL | 00.27 | Shaft
Pipe | 00 Ground floor | 512.5 | Edge= -0.19m SSL | -0.05 m | CC= -0.18m FFB | CC= -0.18m SSL | CC= 3.48m FCL | NN=-0.25 m | NNUK=-0.26 m | Dra.no: 1 | 1 | Storey: 2 | X=30.24 | .001 | Y=11.21 | Top= 3.47m FCL | 00.27 | Shaft
Pipe | 01 First floor | 3250 | Edge= -0.06m SSL | -0.05 m | CC= -0.05m FFB | CC= -0.05m SSL | CC= 3.35m FCL | NN=3.25 m | NNUK=3.24 m | Dra.no: 2 | 3 | Storey: 3 | X=30.97 | .000 | Y=10.94 | Top= 0.00m FCL
Pipe | 02 Second floor | 3062.5 | Edge= -0.31m SSL | -0.30 m | CC= -0.30m FFB | CC= -0.30m SSL | CC= 3.60m FCL | NN=6.50 m | NNUK=6.49 m | Dra.no: 3 | 3 | Storey: 4 | X=30.97 | .000 | Y=10.94 | Top= 0.00m FCL
Pipe | 02 Second floor | 22763.3 | Edge= 2.79m SSL | 2.80 m | CC= 2.80m FFB | CC= 2.80m SSL | CC= 0.50m FCL | NN=9.60 m | NNUK=9.59 m | Dra.no: 3 | 23 | Storey: 4 | X=30.93 | .000 | Y=10.94 | Top= 0.00m FCL
Pipe | 02 Second floor | 804.227 | Edge= 2.66m SSL | 2.80 m | CC= 2.67m FFB | CC= 2.67m SSL | CC= 0.63m FCL | NN=9.60 m | NNUK=9.59 m | Dra.no: 3 | 1 | Storey: 4 | X=8.13 | .000 | Y=10.98 | Top= 0.62m FCL | 02.04 | Installation space
Pipe | 02 Second floor | 2325 | Edge= 2.62m SSL | 2.76 m | CC= 2.63m FFB | CC= 2.63m SSL | CC= 0.67m FCL | NN=9.56 m | NNUK=9.55 m | Dra.no: 3 | 2 | Storey: 4 | X=8.13 | .000 | Y=11.82 | Top= 0.66m FCL | 02.04 | Installation space
Pipe | 02 Second floor | 372.499 | Edge= 0.26m SSL | 0.40 m | CC= 0.27m FFB | CC= 0.27m SSL | CC= 3.03m FCL | NN=7.20 m | NNUK=7.19 m | Dra.no: 3 | 0 | Storey: 4 | X=8.13 | .000 | Y=11.86 | Top= 3.02m FCL | 02.04 | Installation space
Pipe | 02 Second floor | 592.03 | Edge= 0.26m SSL | 0.40 m | CC= 0.27m FFB | CC= 0.27m SSL | CC= 3.03m FCL | NN=7.20 m | NNUK=7.19 m | Dra.no: 3 | 1 | Storey: 4 | X=8.13 | .000 | Y=12.27 | Top= 3.02m FCL | 02.04 | Installation space
Pipe | 02 Second floor | 573.529 | Edge= 0.26m SSL | 0.40 m | CC= 0.27m FFB | CC= 0.27m SSL | CC= 3.03m FCL | NN=7.20 m | NNUK=7.19 m | Dra.no: 3 | 1 | Storey: 4 | X=8.13 | .000 | Y=12.90 | Top= 3.02m FCL | 02.04 | Installation space
Pipe | 02 Second floor | 28.9939 | Edge= 0.26m SSL | 0.40 m | CC= 0.27m FFB | CC= 0.27m SSL | CC= 3.03m FCL | NN=7.20 m | NNUK=7.19 m | Dra.no: 3 | 0 | Storey: 4 | X=8.09 | .000 | Y=13.51 | Top= 3.02m FCL | 02.04 | Installation space
Pipe | 02 Second floor | 213.452 | Edge= 0.29m SSL | 0.44 m | CC= 0.31m FFB | CC= 0.31m SSL | CC= 2.99m FCL | NN=7.24 m | NNUK=7.23 m | Dra.no: 3 | 0 | Storey: 4 | X=8.03 | .000 | Y=13.51 | Top= 2.98m FCL | 02.04 | Installation space
Pipe | 02 Second floor | 212.5 | Edge= 0.51m SSL | 0.65 m | CC= 0.52m FFB | CC= 0.52m SSL | CC= 2.78m FCL | NN=7.45 m | NNUK=7.44 m | Dra.no: 3 | 0 | Storey: 4 | X=8.03 | .000 | Y=12.25 | Top= 2.77m FCL | 02.04 | Installation space
Pipe | 02 Second floor | 48.25 | Edge= 0.26m SSL | 0.40 m | CC= 0.27m FFB | CC= 0.27m SSL | CC= 3.03m FCL | NN=7.20 m | NNUK=7.19 m | Dra.no: 3 | 0 | Storey: 4 | X=8.06 | .000 | Y=12.25 | Top= 3.02m FCL | 02.04 | Installation space
Pipe | 02 Second floor | 212.5 | Edge= 0.51m SSL | 0.65 m | CC= 0.52m FFB | CC= 0.52m SSL | CC= 2.78m FCL | NN=7.45 m | NNUK=7.44 m | Dra.no: 3 | 0 | Storey: 4 | X=8.03 | .000 | Y=12.88 | Top= 2.77m FCL | 02.04 | Installation space
Pipe | 02 Second floor | 48.25 | Edge= 0.26m SSL | 0.40 m | CC= 0.27m FFB | CC= 0.27m SSL | CC= 3.03m FCL | NN=7.20 m | NNUK=7.19 m | Dra.no: 3 | 0 | Storey: 4 | X=8.06 | .000 | Y=12.88 | Top= 3.02m FCL | 02.04 | Installation space

# IfcFlowSegment: SS091209007 (95)
Type - Description: Copper pipes length 5 m 35x1,5 mm; ApplicableOccurrence: Copper; PredefinedType: RIGIDSEGMENT
Type - Pset_ManufacturerTypeInformation - ArticleNumber: SS091209007; ModelReference: Copper pipes length 5 m 35x1,5 mm; Manufacturer: DDS
Type - Pset_PipeSegmentTypeCommon - NominalDiameter: 32; InnerDiameter: 32; OuterDiameter: 35
Pset_DDS - Pressure drop: 0 Pa; Drain slope: 1:0; Manufacturer: DDS; Width: 32; Dimension DN: 32; Drain slope (%): 10000.0 %; Project name: OpenBIM; Insulation k-value: 0; Drain Qww: Qww=0.00 l/s; Flow (l/h): 0.000000 l/h; Outside dimension: 35.000000; Drain slope (\X\B0): 90.0\X\B0; Temperature: 0.00 \X\B0C; Drain DU: DU=0.00 l/s; Product Number: SS091209007; Building Part: Building: 0; Peak flow (l/s): 0.00 l/s; Flow (l/s): 0.00 l/s; Flowsegment thickness: x1.5; Abs. pressure: 0.0 Pa; Velocity: 0.00 m/s; Product: Copper pipes length 5 m 35x1,5 mm
AC_Pset_RenovationAndPhasing - Renovation Status: Existing
Name | In | Material | X | Mounting Height | Mtg. Below Ceiling ref Center | Main string number | Mtg. Above Slab ref Bottom | Mtg. above Finished Floor ref Center | Mtg. Above Slab ref Center | Ins thickness | Model Number | Layer number | Above Sea Level ref. Center | Pset_DDS, Length | Insulation WSVO | Floor number | Y | Part number | Above Sea Level ref. Bottom | Sub string number | Medium | Mtg. Below Ceiling ref Top | Pset_FlowSegmentPipeSegment, Length (mm) | Insulation product text | Insulation product number | Room tekst | Room number
01.0001.00 | 00 Ground floor | ML-Copper pipes length 5 m 35x1,5 mm | X=30.81 | 2.80 m | CC= 0.70m FCL | 01 | Edge= 2.78m SSL | CC= 2.80m FFB | CC= 2.80m SSL | ins= 0.000000 mm | Dra.no: 1 | 188 | NN=2.60 m | 0 | 0 | Storey: 2 | Y=13.25 | .000 | NNUK=2.58 m | .0001 | Cooling Flow | Top= 0.00m FCL | 27 | Group: Cooling flow
01.0001.05 | 00 Ground floor | ML-Copper pipes length 5 m 35x1,5 mm | X=30.76 | 3.20 m | CC= 0.30m FCL | 01 | Edge= 3.18m SSL | CC= 3.20m FFB | CC= 3.20m SSL | ins= 0.000000 mm | Dra.no: 1 | 188 | NN=3.00 m | 0 | 0 | Storey: 2 | Y=13.25 | .005 | NNUK=2.98 m | .0001 | Cooling Flow | Top= 0.00m FCL | 352 | Group: Cooling flow
02.0001.00 | 01 First floor | ML-Copper pipes length 5 m 35x1,5 mm-Pipe insulation 9x35 mm gray insulation thickness 9 mm-9 | X=30.76 | 3.20 m | CC= 0.10m FCL | 02 | Edge= 3.17m SSL | CC= 3.20m FFB | CC= 3.20m SSL | ins= 9.000000 mm | Dra.no: 2 | 188 | NN=6.50 m | 4 | 0 | Storey: 3 | Y=13.25 | .000 | NNUK=6.48 m | .0001 | Cooling Flow | Top= 0.00m FCL | 3500 | Pipe insulation | ZP150/935 | Group: Cooling flow; Pset_DDS - System Name: Cooling
03.0001.00 | 01 First floor | ML-Copper pipes length 5 m 35x1,5 mm-Pipe insulation 9x35 mm gray insulation thickness 9 mm-9 | X=30.76 | 3.20 m | CC= 0.10m FCL | 03 | Edge= 3.18m SSL | CC= 3.20m FFB | CC= 3.20m SSL | ins= 9.000000 mm | Dra.no: 2 | 189 | NN=6.50 m | 4 | 0 | Storey: 3 | Y=13.18 | .000 | NNUK=6.48 m | .0001 | Cooling return | Top= 0.00m FCL | 3500 | Pipe insulation | ZP150/935 | Group: Cooling return; Pset_DDS - System Name: Cooling
02.0001.00 | 02 Second floor | ML-Copper pipes length 5 m 35x1,5 mm-Pipe insulation 9x35 mm gray insulation thickness 9 mm-9 | X=30.76 | 3.25 m | CC= 0.05m FCL | 02 | Edge= 3.23m SSL | CC= 3.25m FFB | CC= 3.25m SSL | ins= 9.000000 mm | Dra.no: 3 | 188 | NN=10.05 m | 4 | 0 | Storey: 4 | Y=13.25 | .000 | NNUK=10.03 m | .0001 | Cooling Flow | Top= 0.00m FCL | 3550 | Pipe insulation | ZP150/935 | Group: Cooling flow; Pset_DDS - System Name: Cooling
03.0001.00 | 02 Second floor | ML-Copper pipes length 5 m 35x1,5 mm-Pipe insulation 9x35 mm gray insulation thickness 9 mm-9 | X=30.76 | 3.25 m | CC= 0.05m FCL | 03 | Edge= 3.23m SSL | CC= 3.25m FFB | CC= 3.25m SSL | ins= 9.000000 mm | Dra.no: 3 | 189 | NN=10.05 m | 4 | 0 | Storey: 4 | Y=13.18 | .000 | NNUK=10.03 m | .0001 | Cooling return | Top= 0.00m FCL | 3550 | Pipe insulation | ZP150/935 | Group: Cooling return; Pset_DDS - System Name: Cooling
02.0001.00 | 03. Roof | ML-Copper pipes length 5 m 35x1,5 mm-Pipe insulation 9x35 mm gray insulation thickness 9 mm-9 | X=32.06 | 0.50 m | CC= 2.87m FCL | 02 | Edge= 0.47m SSL | CC= 0.50m FFB | CC= 0.50m SSL | ins= 9.000000 mm | Dra.no: 4 | 188 | NN=10.80 m | 1 | 0 | Storey: 5 | Y=13.25 | .000 | NNUK=10.78 m | .0001 | Cooling Flow | Top= 0.00m FCL | 1255.46 | Pipe insulation | ZP150/935 | Group: Cooling flow
02.0001.04 | 03. Roof | ML-Copper pipes length 5 m 35x1,5 mm-Pipe insulation 9x35 mm gray insulation thickness 9 mm-9 | X=30.76 | 0.45 m | CC= 2.92m FCL | 02 | Edge= 0.43m SSL | CC= 0.45m FFB | CC= 0.45m SSL | ins= 9.000000 mm | Dra.no: 4 | 188 | NN=10.75 m | 1 | 0 | Storey: 5 | Y=13.25 | .004 | NNUK=10.73 m | .0001 | Cooling Flow | Top= 0.00m FCL | 702 | Pipe insulation | ZP150/935 | Group: Cooling flow
03.0001.00 | 03. Roof | ML-Copper pipes length 5 m 35x1,5 mm-Pipe insulation 9x35 mm gray insulation thickness 9 mm-9 | X=32.06 | 0.50 m | CC= 2.87m FCL | 03 | Edge= 0.47m SSL | CC= 0.50m FFB | CC= 0.50m SSL | ins= 9.000000 mm | Dra.no: 4 | 189 | NN=10.80 m | 1 | 0 | Storey: 5 | Y=13.18 | .000 | NNUK=10.78 m | .0001 | Cooling return | Top= 0.00m FCL | 1255.46 | Pipe insulation | ZP150/935 | Group: Cooling return
03.0001.07 | 03. Roof | ML-Copper pipes length 5 m 35x1,5 mm-Pipe insulation 9x35 mm gray insulation thickness 9 mm-9 | X=30.76 | 0.45 m | CC= 2.92m FCL | 03 | Edge= 0.43m SSL | CC= 0.45m FFB | CC= 0.45m SSL | ins= 9.000000 mm | Dra.no: 4 | 189 | NN=10.75 m | 1 | 0 | Storey: 5 | Y=13.18 | .007 | NNUK=10.73 m | .0001 | Cooling return | Top= 0.00m FCL | 702 | Pipe insulation | ZP150/935 | Group: Cooling return
Pipe | 00 Ground floor | ML-Copper pipes length 5 m 35x1,5 mm | X=30.76 | 3.20 m | CC= 0.30m FCL | 00 | Edge= 3.18m SSL | CC= 3.20m FFB | CC= 3.20m SSL | ins= 0.000000 mm | Dra.no: 1 | 189 | NN=3.00 m | 0 | 0 | Storey: 2 | Y=13.18 | .000 | NNUK=2.98 m | .0001 | Cooling return | Top= 0.00m FCL | 352
Pipe | 00 Ground floor | ML-Copper pipes length 5 m 35x1,5 mm | X=30.81 | 2.80 m | CC= 0.70m FCL | 00 | Edge= 2.78m SSL | CC= 2.80m FFB | CC= 2.80m SSL | ins= 0.000000 mm | Dra.no: 1 | 189 | NN=2.60 m | 0 | 0 | Storey: 2 | Y=13.18 | .000 | NNUK=2.58 m | .0001 | Cooling return | Top= 0.00m FCL | 28.9939
Pipe | 00 Ground floor | ML-Copper pipes length 5 m 35x1,5 mm | X=20.75 | -0.20 m | CC= 3.50m FCL | 00 | Edge= -0.22m SSL | CC= -0.20m FFB | CC= -0.20m SSL | ins= 0.000000 mm | Dra.no: 1 | 5 | NN=-0.40 m | 2 | 0 | Storey: 2 | Y=22.09 | .000 | NNUK=-0.42 m | .0000 | Heat flow | Top= 3.48m FCL | 2202 |  |  | Office | 001
Pipe | 00 Ground floor | ML-Copper pipes length 5 m 35x1,5 mm | X=23.00 | -0.20 m | CC= 3.50m FCL | 00 | Edge= -0.22m SSL | CC= -0.20m FFB | CC= -0.20m SSL | ins= 0.000000 mm | Dra.no: 1 | 5 | NN=-0.40 m | 2 | 0 | Storey: 2 | Y=22.09 | .000 | NNUK=-0.42 m | .0000 | Heat flow | Top= 3.48m FCL | 2202 |  |  | Storage | 00.22
Pipe | 00 Ground floor | ML-Copper pipes length 5 m 35x1,5 mm | X=25.30 | -0.20 m | CC= 3.50m FCL | 00 | Edge= -0.22m SSL | CC= -0.20m FFB | CC= -0.20m SSL | ins= 0.000000 mm | Dra.no: 1 | 5 | NN=-0.40 m | 2 | 0 | Storey: 2 | Y=22.09 | .000 | NNUK=-0.42 m | .0000 | Heat flow | Top= 3.48m FCL | 2252 |  |  | Hallway | 00.03
Pipe | 00 Ground floor | ML-Copper pipes length 5 m 35x1,5 mm | X=27.55 | -0.20 m | CC= 3.50m FCL | 00 | Edge= -0.22m SSL | CC= -0.20m FFB | CC= -0.20m SSL | ins= 0.000000 mm | Dra.no: 1 | 5 | NN=-0.40 m | 2 | 0 | Storey: 2 | Y=22.09 | .000 | NNUK=-0.42 m | .0000 | Heat flow | Top= 3.48m FCL | 2202 |  |  | Hallway | 00.03
Pipe | 00 Ground floor | ML-Copper pipes length 5 m 35x1,5 mm | X=28.65 | -0.20 m | CC= 3.50m FCL | 00 | Edge= -0.22m SSL | CC= -0.20m FFB | CC= -0.20m SSL | ins= 0.000000 mm | Dra.no: 1 | 5 | NN=-0.40 m | 1 | 0 | Storey: 2 | Y=22.09 | .000 | NNUK=-0.42 m | .0000 | Heat flow | Top= 3.48m FCL | 1048.92 |  |  | Hallway | 00.03
Pipe | 00 Ground floor | ML-Copper pipes length 5 m 35x1,5 mm | X=29.33 | -0.20 m | CC= 3.63m FCL | 00 | Edge= -0.35m SSL | CC= -0.33m FFB | CC= -0.33m SSL | ins= 0.000000 mm | Dra.no: 1 | 5 | NN=-0.40 m | 0 | 0 | Storey: 2 | Y=11.94 | .000 | NNUK=-0.42 m | .0000 | Heat flow | Top= 3.61m FCL | 45.2585 |  |  | Shaft | 00.27
Pipe | 00 Ground floor | ML-Copper pipes length 5 m 35x1,5 mm | X=29.38 | 3.20 m | CC= 0.23m FCL | 00 | Edge= 3.05m SSL | CC= 3.07m FFB | CC= 3.07m SSL | ins= 0.000000 mm | Dra.no: 1 | 5 | NN=3.00 m | 3 | 0 | Storey: 2 | Y=11.94 | .005 | NNUK=2.98 m | .0000 | Heat flow | Top= 0.21m FCL | 3352 |  |  | Shaft | 00.27
Pipe | 00 Ground floor | ML-Copper pipes length 5 m 35x1,5 mm | X=29.33 | -0.10 m | CC= 3.53m FCL | 00 | Edge= -0.25m SSL | CC= -0.23m FFB | CC= -0.23m SSL | ins= 0.000000 mm | Dra.no: 1 | 6 | NN=-0.30 m | 0 | 0 | Storey: 2 | Y=11.83 | .000 | NNUK=-0.32 m | .0000 | Heat return | Top= 3.51m FCL | 45.7759 |  |  | Shaft | 00.27
Pipe | 00 Ground floor | ML-Copper pipes length 5 m 35x1,5 mm | X=29.38 | 3.20 m | CC= 0.23m FCL | 00 | Edge= 3.05m SSL | CC= 3.07m FFB | CC= 3.07m SSL | ins= 0.000000 mm | Dra.no: 1 | 6 | NN=3.00 m | 3 | 0 | Storey: 2 | Y=11.83 | .000 | NNUK=2.98 m | .0000 | Heat return | Top= 0.21m FCL | 3252 |  |  | Shaft | 00.27
Pipe | 00 Ground floor | ML-Copper pipes length 5 m 35x1,5 mm | X=6.18 | 0.14 m | CC= 3.16m FCL | 00 | Edge= 0.12m SSL | CC= 0.14m FFB | CC= 0.14m SSL | ins= 0.000000 mm | Dra.no: 1 | 5 | NN=-0.06 m | 0 | 0 | Storey: 2 | Y=10.68 | .000 | NNUK=-0.08 m | .0000 | Heat flow | Top= 3.15m FCL | 18 |  |  | Office | 00.19
Pipe | 00 Ground floor | ML-Copper pipes length 5 m 35x1,5 mm | X=6.18 | 0.09 m | CC= 3.21m FCL | 00 | Edge= 0.07m SSL | CC= 0.09m FFB | CC= 0.09m SSL | ins= 0.000000 mm | Dra.no: 1 | 5 | NN=-0.11 m | 0 | 0 | Storey: 2 | Y=10.59 | .000 | NNUK=-0.13 m | .0000 | Heat flow | Top= 3.19m FCL | 35 |  |  | Office | 00.19
Pipe | 00 Ground floor | ML-Copper pipes length 5 m 35x1,5 mm | X=6.18 | -0.15 m | CC= 3.45m FCL | 00 | Edge= -0.17m SSL | CC= -0.15m FFB | CC= -0.15m SSL | ins= 0.000000 mm | Dra.no: 1 | 5 | NN=-0.35 m | 0 | 0 | Storey: 2 | Y=10.55 | .000 | NNUK=-0.37 m | .0000 | Heat flow | Top= 3.44m FCL | 194 |  |  | Office | 00.19
Pipe | 00 Ground floor | ML-Copper pipes length 5 m 35x1,5 mm | X=6.18 | -0.20 m | CC= 3.50m FCL | 00 | Edge= -0.22m SSL | CC= -0.20m FFB | CC= -0.20m SSL | ins= 0.000000 mm | Dra.no: 1 | 5 | NN=-0.40 m | 0 | 0 | Storey: 2 | Y=10.80 | .000 | NNUK=-0.42 m | .0000 | Heat flow | Top= 3.48m FCL | 203.589 |  |  | Office | 00.19
Pipe | 00 Ground floor | ML-Copper pipes length 5 m 35x1,5 mm | X=5.52 | -0.20 m | CC= 3.50m FCL | 00 | Edge= -0.22m SSL | CC= -0.20m FFB | CC= -0.20m SSL | ins= 0.000000 mm | Dra.no: 1 | 5 | NN=-0.40 m | 1 | 0 | Storey: 2 | Y=10.84 | .000 | NNUK=-0.42 m | .0000 | Heat flow | Top= 3.48m FCL | 608.52 |  |  | Office | 00.19
Pipe | 00 Ground floor | ML-Copper pipes length 5 m 35x1,5 mm | X=5.47 | -0.20 m | CC= 3.50m FCL | 00 | Edge= -0.22m SSL | CC= -0.20m FFB | CC= -0.20m SSL | ins= 0.000000 mm | Dra.no: 1 | 5 | NN=-0.40 m | 11 | 0 | Storey: 2 | Y=21.40 | .000 | NNUK=-0.42 m | .0000 | Heat flow | Top= 3.48m FCL | 10505.9 |  |  | Staircase | 00.05
Pipe | 00 Ground floor | ML-Copper pipes length 5 m 35x1,5 mm | X=5.47 | -0.20 m | CC= 3.50m FCL | 00 | Edge= -0.22m SSL | CC= -0.20m FFB | CC= -0.20m SSL | ins= 0.000000 mm | Dra.no: 1 | 5 | NN=-0.40 m | 1 | 0 | Storey: 2 | Y=22.04 | .000 | NNUK=-0.42 m | .0000 | Heat flow | Top= 3.48m FCL | 598.431 |  |  | Staircase | 00.05
Pipe | 00 Ground floor | ML-Copper pipes length 5 m 35x1,5 mm | X=7.25 | -0.20 m | CC= 3.50m FCL | 00 | Edge= -0.22m SSL | CC= -0.20m FFB | CC= -0.20m SSL | ins= 0.000000 mm | Dra.no: 1 | 5 | NN=-0.40 m | 2 | 0 | Storey: 2 | Y=22.09 | .000 | NNUK=-0.42 m | .0000 | Heat flow | Top= 3.48m FCL | 1727.52 |  |  | Staircase | 00.05
Pipe | 00 Ground floor | ML-Copper pipes length 5 m 35x1,5 mm | X=9.50 | -0.20 m | CC= 3.50m FCL | 00 | Edge= -0.22m SSL | CC= -0.20m FFB | CC= -0.20m SSL | ins= 0.000000 mm | Dra.no: 1 | 5 | NN=-0.40 m | 2 | 0 | Storey: 2 | Y=22.09 | .000 | NNUK=-0.42 m | .0000 | Heat flow | Top= 3.48m FCL | 2202 |  |  | Office | 00.20
Pipe | 00 Ground floor | ML-Copper pipes length 5 m 35x1,5 mm | X=11.75 | -0.20 m | CC= 3.50m FCL | 00 | Edge= -0.22m SSL | CC= -0.20m FFB | CC= -0.20m SSL | ins= 0.000000 mm | Dra.no: 1 | 5 | NN=-0.40 m | 2 | 0 | Storey: 2 | Y=22.09 | .000 | NNUK=-0.42 m | .0000 | Heat flow | Top= 3.48m FCL | 2202 |  |  | Office | 00.20
Pipe | 00 Ground floor | ML-Copper pipes length 5 m 35x1,5 mm | X=14.00 | -0.20 m | CC= 3.50m FCL | 00 | Edge= -0.22m SSL | CC= -0.20m FFB | CC= -0.20m SSL | ins= 0.000000 mm | Dra.no: 1 | 5 | NN=-0.40 m | 2 | 0 | Storey: 2 | Y=22.09 | .000 | NNUK=-0.42 m | .0000 | Heat flow | Top= 3.48m FCL | 2202 |  |  | Office | 00.21
Pipe | 00 Ground floor | ML-Copper pipes length 5 m 35x1,5 mm | X=16.25 | -0.20 m | CC= 3.50m FCL | 00 | Edge= -0.22m SSL | CC= -0.20m FFB | CC= -0.20m SSL | ins= 0.000000 mm | Dra.no: 1 | 5 | NN=-0.40 m | 2 | 0 | Storey: 2 | Y=22.09 | .000 | NNUK=-0.42 m | .0000 | Heat flow | Top= 3.48m FCL | 2202 |  |  | Office | 00.21
Pipe | 00 Ground floor | ML-Copper pipes length 5 m 35x1,5 mm | X=18.50 | -0.20 m | CC= 3.50m FCL | 00 | Edge= -0.22m SSL | CC= -0.20m FFB | CC= -0.20m SSL | ins= 0.000000 mm | Dra.no: 1 | 5 | NN=-0.40 m | 2 | 0 | Storey: 2 | Y=22.09 | .000 | NNUK=-0.42 m | .0000 | Heat flow | Top= 3.48m FCL | 2202 |  |  | Office | 001
Pipe | 00 Ground floor | ML-Copper pipes length 5 m 35x1,5 mm | X=6.13 | 0.14 m | CC= 3.16m FCL | 00 | Edge= 0.12m SSL | CC= 0.14m FFB | CC= 0.14m SSL | ins= 0.000000 mm | Dra.no: 1 | 6 | NN=-0.06 m | 0 | 0 | Storey: 2 | Y=10.68 | .000 | NNUK=-0.08 m | .0000 | Heat return | Top= 3.15m FCL | 18 |  |  | Office | 00.19
Pipe | 00 Ground floor | ML-Copper pipes length 5 m 35x1,5 mm | X=6.13 | 0.09 m | CC= 3.21m FCL | 00 | Edge= 0.07m SSL | CC= 0.09m FFB | CC= 0.09m SSL | ins= 0.000000 mm | Dra.no: 1 | 6 | NN=-0.11 m | 0 | 0 | Storey: 2 | Y=10.59 | .000 | NNUK=-0.13 m | .0000 | Heat return | Top= 3.19m FCL | 35 |  |  | Office | 00.19
Pipe | 00 Ground floor | ML-Copper pipes length 5 m 35x1,5 mm | X=6.13 | -0.05 m | CC= 3.35m FCL | 00 | Edge= -0.07m SSL | CC= -0.05m FFB | CC= -0.05m SSL | ins= 0.000000 mm | Dra.no: 1 | 6 | NN=-0.25 m | 0 | 0 | Storey: 2 | Y=10.55 | .000 | NNUK=-0.27 m | .0000 | Heat return | Top= 3.34m FCL | 94 |  |  | Office | 00.19
Pipe | 00 Ground floor | ML-Copper pipes length 5 m 35x1,5 mm | X=6.13 | -0.10 m | CC= 3.40m FCL | 00 | Edge= -0.12m SSL | CC= -0.10m FFB | CC= -0.10m SSL | ins= 0.000000 mm | Dra.no: 1 | 6 | NN=-0.30 m | 0 | 0 | Storey: 2 | Y=10.96 | .000 | NNUK=-0.32 m | .0000 | Heat return | Top= 3.38m FCL | 371.064 |  |  | Office | 00.19
Pipe | 00 Ground floor | ML-Copper pipes length 5 m 35x1,5 mm | X=5.65 | -0.10 m | CC= 3.40m FCL | 00 | Edge= -0.12m SSL | CC= -0.10m FFB | CC= -0.10m SSL | ins= 0.000000 mm | Dra.no: 1 | 6 | NN=-0.30 m | 0 | 0 | Storey: 2 | Y=11.01 | .000 | NNUK=-0.32 m | .0000 | Heat return | Top= 3.38m FCL | 427.674 |  |  | Office | 00.19
Pipe | 00 Ground floor | ML-Copper pipes length 5 m 35x1,5 mm | X=5.60 | -0.10 m | CC= 3.40m FCL | 00 | Edge= -0.12m SSL | CC= -0.10m FFB | CC= -0.10m SSL | ins= 0.000000 mm | Dra.no: 1 | 6 | NN=-0.30 m | 10 | 0 | Storey: 2 | Y=21.45 | .000 | NNUK=-0.32 m | .0000 | Heat return | Top= 3.38m FCL | 10388.4 |  |  | Staircase | 00.05
Pipe | 00 Ground floor | ML-Copper pipes length 5 m 35x1,5 mm | X=5.60 | -0.10 m | CC= 3.40m FCL | 00 | Edge= -0.12m SSL | CC= -0.10m FFB | CC= -0.10m SSL | ins= 0.000000 mm | Dra.no: 1 | 6 | NN=-0.30 m | 0 | 0 | Storey: 2 | Y=21.92 | .000 | NNUK=-0.32 m | .0000 | Heat return | Top= 3.38m FCL | 420.413 |  |  | Staircase | 00.05
Pipe | 00 Ground floor | ML-Copper pipes length 5 m 35x1,5 mm | X=7.30 | -0.10 m | CC= 3.40m FCL | 00 | Edge= -0.12m SSL | CC= -0.10m FFB | CC= -0.10m SSL | ins= 0.000000 mm | Dra.no: 1 | 6 | NN=-0.30 m | 2 | 0 | Storey: 2 | Y=21.96 | .000 | NNUK=-0.32 m | .0000 | Heat return | Top= 3.38m FCL | 1646.67 |  |  | Staircase | 00.05
Pipe | 00 Ground floor | ML-Copper pipes length 5 m 35x1,5 mm | X=9.55 | -0.10 m | CC= 3.40m FCL | 00 | Edge= -0.12m SSL | CC= -0.10m FFB | CC= -0.10m SSL | ins= 0.000000 mm | Dra.no: 1 | 6 | NN=-0.30 m | 2 | 0 | Storey: 2 | Y=21.96 | .000 | NNUK=-0.32 m | .0000 | Heat return | Top= 3.38m FCL | 2202 |  |  | Office | 00.20
Pipe | 00 Ground floor | ML-Copper pipes length 5 m 35x1,5 mm | X=11.80 | -0.10 m | CC= 3.40m FCL | 00 | Edge= -0.12m SSL | CC= -0.10m FFB | CC= -0.10m SSL | ins= 0.000000 mm | Dra.no: 1 | 6 | NN=-0.30 m | 2 | 0 | Storey: 2 | Y=21.96 | .000 | NNUK=-0.32 m | .0000 | Heat return | Top= 3.38m FCL | 2202 |  |  | Office | 00.20
Pipe | 00 Ground floor | ML-Copper pipes length 5 m 35x1,5 mm | X=14.05 | -0.10 m | CC= 3.40m FCL | 00 | Edge= -0.12m SSL | CC= -0.10m FFB | CC= -0.10m SSL | ins= 0.000000 mm | Dra.no: 1 | 6 | NN=-0.30 m | 2 | 0 | Storey: 2 | Y=21.96 | .000 | NNUK=-0.32 m | .0000 | Heat return | Top= 3.38m FCL | 2202 |  |  | Office | 00.21
Pipe | 00 Ground floor | ML-Copper pipes length 5 m 35x1,5 mm | X=16.30 | -0.10 m | CC= 3.40m FCL | 00 | Edge= -0.12m SSL | CC= -0.10m FFB | CC= -0.10m SSL | ins= 0.000000 mm | Dra.no: 1 | 6 | NN=-0.30 m | 2 | 0 | Storey: 2 | Y=21.96 | .000 | NNUK=-0.32 m | .0000 | Heat return | Top= 3.38m FCL | 2202 |  |  | Office | 00.21
Pipe | 00 Ground floor | ML-Copper pipes length 5 m 35x1,5 mm | X=18.55 | -0.10 m | CC= 3.40m FCL | 00 | Edge= -0.12m SSL | CC= -0.10m FFB | CC= -0.10m SSL | ins= 0.000000 mm | Dra.no: 1 | 6 | NN=-0.30 m | 2 | 0 | Storey: 2 | Y=21.96 | .000 | NNUK=-0.32 m | .0000 | Heat return | Top= 3.38m FCL | 2202 |  |  | Office | 001
Pipe | 00 Ground floor | ML-Copper pipes length 5 m 35x1,5 mm | X=20.80 | -0.10 m | CC= 3.40m FCL | 00 | Edge= -0.12m SSL | CC= -0.10m FFB | CC= -0.10m SSL | ins= 0.000000 mm | Dra.no: 1 | 6 | NN=-0.30 m | 2 | 0 | Storey: 2 | Y=21.96 | .000 | NNUK=-0.32 m | .0000 | Heat return | Top= 3.38m FCL | 2202 |  |  | Office | 001
Pipe | 00 Ground floor | ML-Copper pipes length 5 m 35x1,5 mm | X=23.05 | -0.10 m | CC= 3.40m FCL | 00 | Edge= -0.12m SSL | CC= -0.10m FFB | CC= -0.10m SSL | ins= 0.000000 mm | Dra.no: 1 | 6 | NN=-0.30 m | 2 | 0 | Storey: 2 | Y=21.96 | .000 | NNUK=-0.32 m | .0000 | Heat return | Top= 3.38m FCL | 2202 |  |  | Storage | 00.22
Pipe | 00 Ground floor | ML-Copper pipes length 5 m 35x1,5 mm | X=25.35 | -0.10 m | CC= 3.40m FCL | 00 | Edge= -0.12m SSL | CC= -0.10m FFB | CC= -0.10m SSL | ins= 0.000000 mm | Dra.no: 1 | 6 | NN=-0.30 m | 2 | 0 | Storey: 2 | Y=21.96 | .000 | NNUK=-0.32 m | .0000 | Heat return | Top= 3.38m FCL | 2252 |  |  | Hallway | 00.03
Pipe | 00 Ground floor | ML-Copper pipes length 5 m 35x1,5 mm | X=27.60 | -0.10 m | CC= 3.40m FCL | 00 | Edge= -0.12m SSL | CC= -0.10m FFB | CC= -0.10m SSL | ins= 0.000000 mm | Dra.no: 1 | 6 | NN=-0.30 m | 2 | 0 | Storey: 2 | Y=21.96 | .000 | NNUK=-0.32 m | .0000 | Heat return | Top= 3.38m FCL | 2202 |  |  | Hallway | 00.03
Pipe | 00 Ground floor | ML-Copper pipes length 5 m 35x1,5 mm | X=28.55 | -0.10 m | CC= 3.40m FCL | 00 | Edge= -0.12m SSL | CC= -0.10m FFB | CC= -0.10m SSL | ins= 0.000000 mm | Dra.no: 1 | 6 | NN=-0.30 m | 1 | 0 | Storey: 2 | Y=21.96 | .000 | NNUK=-0.32 m | .0000 | Heat return | Top= 3.38m FCL | 900.521 |  |  | Hallway | 00.03
Pipe | 01 First floor | ML-Copper pipes length 5 m 35x1,5 mm-Mineral fibre plastic covered 30x35-30 | X=29.38 | -0.22 m | CC= 3.52m FCL | 00 | Edge= -0.27m SSL | CC= -0.22m FFB | CC= -0.22m SSL | ins= 30.000000 mm | Dra.no: 2 | 6 | NN=3.08 m | 0 | 100 | Storey: 3 | Y=11.83 | .000 | NNUK=3.03 m | .0000 | Heat return | Top= 0.00m FCL | 79 | Fibre plastic covered | MK032100
Pipe | 01 First floor | ML-Copper pipes length 5 m 35x1,5 mm-Mineral fibre plastic covered 30x35-30 | X=29.38 | 3.20 m | CC= 0.10m FCL | 00 | Edge= 3.15m SSL | CC= 3.20m FFB | CC= 3.20m SSL | ins= 30.000000 mm | Dra.no: 2 | 6 | NN=6.50 m | 3 | 100 | Storey: 3 | Y=11.83 | .000 | NNUK=6.45 m | .0000 | Heat return | Top= 0.00m FCL | 3379 | Fibre plastic covered | MK032100
Pipe | 01 First floor | ML-Copper pipes length 5 m 35x1,5 mm-Mineral fibre plastic covered 30x35-30 | X=29.38 | -0.12 m | CC= 3.42m FCL | 00 | Edge= -0.17m SSL | CC= -0.12m FFB | CC= -0.12m SSL | ins= 30.000000 mm | Dra.no: 2 | 5 | NN=3.18 m | 0 | 100 | Storey: 3 | Y=11.94 | .000 | NNUK=3.13 m | .0000 | Heat flow | Top= 0.00m FCL | 179 | Fibre plastic covered | MK032100
Pipe | 01 First floor | ML-Copper pipes length 5 m 35x1,5 mm-Mineral fibre plastic covered 30x35-30 | X=29.38 | 3.20 m | CC= 0.10m FCL | 00 | Edge= 3.15m SSL | CC= 3.20m FFB | CC= 3.20m SSL | ins= 30.000000 mm | Dra.no: 2 | 5 | NN=6.50 m | 3 | 100 | Storey: 3 | Y=11.94 | .005 | NNUK=6.45 m | .0000 | Heat flow | Top= 0.00m FCL | 3279 | Fibre plastic covered | MK032100
Pipe | 02 Second floor | ML-Copper pipes length 5 m 35x1,5 mm-Pipe insulation 9x35 mm gray insulation thickness 9 mm-9 | X=8.07 | 0.20 m | CC= 3.23m FCL | 00 | Edge= 0.04m SSL | CC= 0.07m FFB | CC= 0.07m SSL | ins= 9.000000 mm | Dra.no: 3 | 5 | NN=7.00 m | 0 | 0 | Storey: 4 | Y=12.19 | .000 | NNUK=6.98 m | .0000 | Heat flow | Top= 3.21m FCL | 145 | Pipe insulation | ZP150/935 | Installation space | 02.04
Pipe | 02 Second floor | ML-Copper pipes length 5 m 35x1,5 mm-Mineral fibre plastic covered 30x35-30 | X=8.61 | 2.70 m | CC= 0.73m FCL | 00 | Edge= 2.52m SSL | CC= 2.57m FFB | CC= 2.57m SSL | ins= 30.000000 mm | Dra.no: 3 | 6 | NN=9.50 m | 20 | 100 | Storey: 4 | Y=11.21 | .000 | NNUK=9.45 m | .0000 | Heat return | Top= 0.68m FCL | 19609.9 | Fibre plastic covered | MK032100 | Installation space | 02.04
Pipe | 02 Second floor | ML-Copper pipes length 5 m 35x1,5 mm-Pipe insulation 9x35 mm gray insulation thickness 9 mm-9 | X=8.27 | 0.20 m | CC= 3.23m FCL | 00 | Edge= 0.04m SSL | CC= 0.07m FFB | CC= 0.07m SSL | ins= 9.000000 mm | Dra.no: 3 | 5 | NN=7.00 m | 1 | 0 | Storey: 4 | Y=12.24 | .000 | NNUK=6.98 m | .0000 | Heat flow | Top= 3.21m FCL | 506.881 | Pipe insulation | ZP150/935 | Installation space | 02.04
Pipe | 02 Second floor | ML-Copper pipes length 5 m 35x1,5 mm-Mineral fibre plastic covered 30x35-30 | X=8.56 | 2.70 m | CC= 0.73m FCL | 00 | Edge= 2.52m SSL | CC= 2.57m FFB | CC= 2.57m SSL | ins= 30.000000 mm | Dra.no: 3 | 6 | NN=9.50 m | 4 | 100 | Storey: 4 | Y=15.17 | .000 | NNUK=9.45 m | .0000 | Heat return | Top= 0.68m FCL | 3912.08 | Fibre plastic covered | MK032100 | Installation space | 02.04
Pipe | 02 Second floor | ML-Copper pipes length 5 m 35x1,5 mm-Mineral fibre plastic covered 30x35-30 | X=8.16 | 2.70 m | CC= 0.73m FCL | 00 | Edge= 2.52m SSL | CC= 2.57m FFB | CC= 2.57m SSL | ins= 30.000000 mm | Dra.no: 3 | 6 | NN=9.50 m | 0 | 100 | Storey: 4 | Y=15.22 | .000 | NNUK=9.45 m | .0000 | Heat return | Top= 0.68m FCL | 349.178 | Fibre plastic covered | MK032100 | Installation space | 02.04
Pipe | 02 Second floor | ML-Copper pipes length 5 m 35x1,5 mm-Mineral fibre plastic covered 30x35-30 | X=8.12 | 1.90 m | CC= 1.53m FCL | 00 | Edge= 1.72m SSL | CC= 1.77m FFB | CC= 1.77m SSL | ins= 30.000000 mm | Dra.no: 3 | 6 | NN=8.70 m | 1 | 100 | Storey: 4 | Y=15.22 | .000 | NNUK=8.65 m | .0000 | Heat return | Top= 1.48m FCL | 752 | Fibre plastic covered | MK032100 | Installation space | 02.04
Pipe | 02 Second floor | ML-Copper pipes length 5 m 35x1,5 mm-Mineral fibre plastic covered 30x35-30 | X=29.38 | 2.55 m | CC= 0.75m FCL | 00 | Edge= 2.51m SSL | CC= 2.55m FFB | CC= 2.55m SSL | ins= 30.000000 mm | Dra.no: 3 | 5 | NN=9.35 m | 3 | 100 | Storey: 4 | Y=11.94 | .000 | NNUK=9.31 m | .0000 | Heat flow | Top= 0.00m FCL | 2852 | Fibre plastic covered | MK032100
Pipe | 02 Second floor | ML-Copper pipes length 5 m 35x1,5 mm-Mineral fibre plastic covered 30x35-30 | X=28.20 | 2.60 m | CC= 0.83m FCL | 00 | Edge= 2.42m SSL | CC= 2.47m FFB | CC= 2.47m SSL | ins= 30.000000 mm | Dra.no: 3 | 5 | NN=9.40 m | 1 | 100 | Storey: 4 | Y=11.94 | .000 | NNUK=9.35 m | .0000 | Heat flow | Top= 0.78m FCL | 1130.83 | Fibre plastic covered | MK032100 | Unnamed | 02.03
Pipe | 02 Second floor | ML-Copper pipes length 5 m 35x1,5 mm-Mineral fibre plastic covered 30x35-30 | X=28.15 | 2.60 m | CC= 0.83m FCL | 00 | Edge= 2.42m SSL | CC= 2.47m FFB | CC= 2.47m SSL | ins= 30.000000 mm | Dra.no: 3 | 5 | NN=9.40 m | 1 | 100 | Storey: 4 | Y=11.38 | .000 | NNUK=9.35 m | .0000 | Heat flow | Top= 0.78m FCL | 518.844 | Fibre plastic covered | MK032100 | Unnamed | 02.03
Pipe | 02 Second floor | ML-Copper pipes length 5 m 35x1,5 mm-Mineral fibre plastic covered 30x35-30 | X=8.50 | 2.60 m | CC= 0.83m FCL | 00 | Edge= 2.42m SSL | CC= 2.47m FFB | CC= 2.47m SSL | ins= 30.000000 mm | Dra.no: 3 | 5 | NN=9.40 m | 20 | 100 | Storey: 4 | Y=11.33 | .000 | NNUK=9.35 m | .0000 | Heat flow | Top= 0.78m FCL | 19608.6 | Fibre plastic covered | MK032100 | Installation space | 02.04
Pipe | 02 Second floor | ML-Copper pipes length 5 m 35x1,5 mm-Mineral fibre plastic covered 30x35-30 | X=8.45 | 2.60 m | CC= 0.83m FCL | 00 | Edge= 2.42m SSL | CC= 2.47m FFB | CC= 2.47m SSL | ins= 30.000000 mm | Dra.no: 3 | 5 | NN=9.40 m | 4 | 100 | Storey: 4 | Y=15.05 | .000 | NNUK=9.35 m | .0000 | Heat flow | Top= 0.78m FCL | 3671.45 | Fibre plastic covered | MK032100 | Installation space | 02.04
Pipe | 02 Second floor | ML-Copper pipes length 5 m 35x1,5 mm-Mineral fibre plastic covered 30x35-30 | X=29.38 | 2.65 m | CC= 0.65m FCL | 00 | Edge= 2.61m SSL | CC= 2.65m FFB | CC= 2.65m SSL | ins= 30.000000 mm | Dra.no: 3 | 6 | NN=9.45 m | 3 | 100 | Storey: 4 | Y=11.83 | .000 | NNUK=9.41 m | .0000 | Heat return | Top= 0.00m FCL | 2952 | Fibre plastic covered | MK032100
Pipe | 02 Second floor | ML-Copper pipes length 5 m 35x1,5 mm-Mineral fibre plastic covered 30x35-30 | X=28.31 | 2.70 m | CC= 0.73m FCL | 00 | Edge= 2.52m SSL | CC= 2.57m FFB | CC= 2.57m SSL | ins= 30.000000 mm | Dra.no: 3 | 6 | NN=9.50 m | 1 | 100 | Storey: 4 | Y=11.83 | .000 | NNUK=9.45 m | .0000 | Heat return | Top= 0.68m FCL | 1018.49 | Fibre plastic covered | MK032100 | Unnamed | 02.03
Pipe | 02 Second floor | ML-Copper pipes length 5 m 35x1,5 mm-Pipe insulation 9x35 mm gray insulation thickness 9 mm-9 | X=8.03 | 0.65 m | CC= 2.78m FCL | 00 | Edge= 0.49m SSL | CC= 0.52m FFB | CC= 0.52m SSL | ins= 9.000000 mm | Dra.no: 3 | 5 | NN=7.45 m | 0 | 0 | Storey: 4 | Y=12.19 | .000 | NNUK=7.43 m | .0000 | Heat flow | Top= 2.76m FCL | 401.811 | Pipe insulation | ZP150/935 | Installation space | 02.04
Pipe | 02 Second floor | ML-Copper pipes length 5 m 35x1,5 mm-Mineral fibre plastic covered 30x35-30 | X=28.27 | 2.70 m | CC= 0.73m FCL | 00 | Edge= 2.52m SSL | CC= 2.57m FFB | CC= 2.57m SSL | ins= 30.000000 mm | Dra.no: 3 | 6 | NN=9.50 m | 1 | 100 | Storey: 4 | Y=11.26 | .000 | NNUK=9.45 m | .0000 | Heat return | Top= 0.68m FCL | 526.652 | Fibre plastic covered | MK032100 | Unnamed | 02.03
Pipe | 02 Second floor | ML-Copper pipes length 5 m 35x1,5 mm-Mineral fibre plastic covered 30x35-30 | X=16.29 | 2.35 m | CC= 1.08m FCL | 00 | Edge= 2.18m SSL | CC= 2.22m FFB | CC= 2.22m SSL | ins= 30.000000 mm | Dra.no: 3 | 5 | NN=9.15 m | 2 | 100 | Storey: 4 | Y=12.85 | .000 | NNUK=9.11 m | .0000 | Heat flow | Top= 1.03m FCL | 1704 | Fibre plastic covered | MK032100 | Installation space | 02.04
Pipe | 02 Second floor | ML-Copper pipes length 5 m 35x1,5 mm-Mineral fibre plastic covered 30x35-30 | X=8.86 | 2.40 m | CC= 1.03m FCL | 00 | Edge= 2.22m SSL | CC= 2.27m FFB | CC= 2.27m SSL | ins= 30.000000 mm | Dra.no: 3 | 5 | NN=9.20 m | 7 | 100 | Storey: 4 | Y=12.85 | .000 | NNUK=9.15 m | .0000 | Heat flow | Top= 0.98m FCL | 7386.23 | Fibre plastic covered | MK032100 | Installation space | 02.04
Pipe | 02 Second floor | ML-Copper pipes length 5 m 35x1,5 mm-Mineral fibre plastic covered 30x35-30 | X=8.81 | 2.40 m | CC= 1.03m FCL | 00 | Edge= 2.22m SSL | CC= 2.27m FFB | CC= 2.27m SSL | ins= 30.000000 mm | Dra.no: 3 | 5 | NN=9.20 m | 2 | 100 | Storey: 4 | Y=14.80 | .000 | NNUK=9.15 m | .0000 | Heat flow | Top= 0.98m FCL | 1899 | Fibre plastic covered | MK032100 | Installation space | 02.04
Pipe | 02 Second floor | ML-Copper pipes length 5 m 35x1,5 mm-Mineral fibre plastic covered 30x35-30 | X=8.31 | 2.40 m | CC= 1.03m FCL | 00 | Edge= 2.22m SSL | CC= 2.27m FFB | CC= 2.27m SSL | ins= 30.000000 mm | Dra.no: 3 | 5 | NN=9.20 m | 0 | 100 | Storey: 4 | Y=14.84 | .000 | NNUK=9.15 m | .0000 | Heat flow | Top= 0.98m FCL | 447.037 | Fibre plastic covered | MK032100 | Installation space | 02.04
Pipe | 02 Second floor | ML-Copper pipes length 5 m 35x1,5 mm-Mineral fibre plastic covered 30x35-30 | X=8.27 | 1.90 m | CC= 1.53m FCL | 00 | Edge= 1.72m SSL | CC= 1.77m FFB | CC= 1.77m SSL | ins= 30.000000 mm | Dra.no: 3 | 5 | NN=8.70 m | 0 | 100 | Storey: 4 | Y=14.84 | .000 | NNUK=8.65 m | .0000 | Heat flow | Top= 1.48m FCL | 452 | Fibre plastic covered | MK032100 | Installation space | 02.04
Pipe | 02 Second floor | ML-Copper pipes length 5 m 35x1,5 mm-Pipe insulation 9x35 mm gray insulation thickness 9 mm-9 | X=8.03 | 0.65 m | CC= 2.78m FCL | 00 | Edge= 0.49m SSL | CC= 0.52m FFB | CC= 0.52m SSL | ins= 9.000000 mm | Dra.no: 3 | 6 | NN=7.45 m | 1 | 0 | Storey: 4 | Y=13.57 | .000 | NNUK=7.43 m | .0000 | Heat return | Top= 2.76m FCL | 512.5 | Pipe insulation | ZP150/935 | Installation space | 02.04
Pipe | 02 Second floor | ML-Copper pipes length 5 m 35x1,5 mm-Pipe insulation 9x35 mm gray insulation thickness 9 mm-9 | X=8.03 | 0.65 m | CC= 2.78m FCL | 00 | Edge= 0.49m SSL | CC= 0.52m FFB | CC= 0.52m SSL | ins= 9.000000 mm | Dra.no: 3 | 6 | NN=7.45 m | 1 | 0 | Storey: 4 | Y=12.94 | .000 | NNUK=7.43 m | .0000 | Heat return | Top= 2.76m FCL | 521 | Pipe insulation | ZP150/935 | Installation space | 02.04
Pipe | 02 Second floor | ML-Copper pipes length 5 m 35x1,5 mm-Mineral fibre plastic covered 30x35-30 | X=8.31 | 2.60 m | CC= 0.83m FCL | 00 | Edge= 2.42m SSL | CC= 2.47m FFB | CC= 2.47m SSL | ins= 30.000000 mm | Dra.no: 3 | 5 | NN=9.40 m | 0 | 100 | Storey: 4 | Y=15.09 | .000 | NNUK=9.35 m | .0000 | Heat flow | Top= 0.78m FCL | 87.9382 | Fibre plastic covered | MK032100 | Installation space | 02.04
Pipe | 02 Second floor | ML-Copper pipes length 5 m 35x1,5 mm-Pipe insulation 9x35 mm gray insulation thickness 9 mm-9 | X=8.03 | 0.65 m | CC= 2.78m FCL | 00 | Edge= 0.49m SSL | CC= 0.52m FFB | CC= 0.52m SSL | ins= 9.000000 mm | Dra.no: 3 | 5 | NN=7.45 m | 0 | 0 | Storey: 4 | Y=12.82 | .000 | NNUK=7.43 m | .0000 | Heat flow | Top= 2.76m FCL | 401.811 | Pipe insulation | ZP150/935 | Installation space | 02.04
Pipe | 02 Second floor | ML-Copper pipes length 5 m 35x1,5 mm-Mineral fibre plastic covered 30x35-30 | X=8.27 | 1.90 m | CC= 1.53m FCL | 00 | Edge= 1.72m SSL | CC= 1.77m FFB | CC= 1.77m SSL | ins= 30.000000 mm | Dra.no: 3 | 5 | NN=8.70 m | 1 | 100 | Storey: 4 | Y=15.09 | .000 | NNUK=8.65 m | .0000 | Heat flow | Top= 1.48m FCL | 652 | Fibre plastic covered | MK032100 | Installation space | 02.04
Pipe | 02 Second floor | ML-Copper pipes length 5 m 35x1,5 mm-Mineral fibre plastic covered 30x35-30 | X=16.55 | 1.20 m | CC= 2.23m FCL | 00 | Edge= 1.02m SSL | CC= 1.07m FFB | CC= 1.07m SSL | ins= 30.000000 mm | Dra.no: 3 | 6 | NN=8.00 m | 0 | 100 | Storey: 4 | Y=12.85 | .000 | NNUK=7.95 m | .0000 | Heat return | Top= 2.18m FCL | 73.9578 | Fibre plastic covered | MK032100 | Installation space | 02.04
Pipe | 02 Second floor | ML-Copper pipes length 5 m 35x1,5 mm-Pipe insulation 9x35 mm gray insulation thickness 9 mm-9 | X=8.07 | 0.20 m | CC= 3.23m FCL | 00 | Edge= 0.04m SSL | CC= 0.07m FFB | CC= 0.07m SSL | ins= 9.000000 mm | Dra.no: 3 | 5 | NN=7.00 m | 0 | 0 | Storey: 4 | Y=12.82 | .000 | NNUK=6.98 m | .0000 | Heat flow | Top= 3.21m FCL | 163.703 | Pipe insulation | ZP150/935 | Installation space | 02.04
Pipe | 02 Second floor | ML-Copper pipes length 5 m 35x1,5 mm-Mineral fibre plastic covered 30x35-30 | X=16.51 | 2.35 m | CC= 1.08m FCL | 00 | Edge= 2.18m SSL | CC= 2.22m FFB | CC= 2.22m SSL | ins= 30.000000 mm | Dra.no: 3 | 6 | NN=9.15 m | 1 | 100 | Storey: 4 | Y=12.85 | .000 | NNUK=9.11 m | .0000 | Heat return | Top= 1.03m FCL | 1104 | Fibre plastic covered | MK032100 | Installation space | 02.04
Pipe | 02 Second floor | ML-Copper pipes length 5 m 35x1,5 mm-Pipe insulation 9x35 mm gray insulation thickness 9 mm-9 | X=8.03 | 0.65 m | CC= 2.78m FCL | 00 | Edge= 0.49m SSL | CC= 0.52m FFB | CC= 0.52m SSL | ins= 9.000000 mm | Dra.no: 3 | 5 | NN=7.45 m | 0 | 0 | Storey: 4 | Y=13.45 | .000 | NNUK=7.43 m | .0000 | Heat flow | Top= 2.76m FCL | 401.811 | Pipe insulation | ZP150/935 | Installation space | 02.04
Pipe | 02 Second floor | ML-Copper pipes length 5 m 35x1,5 mm-Mineral fibre plastic covered 30x35-30 | X=16.44 | 2.40 m | CC= 1.03m FCL | 00 | Edge= 2.22m SSL | CC= 2.27m FFB | CC= 2.27m SSL | ins= 30.000000 mm | Dra.no: 3 | 6 | NN=9.20 m | 0 | 100 | Storey: 4 | Y=12.85 | .000 | NNUK=9.15 m | .0000 | Heat return | Top= 0.98m FCL | 15.3951 | Fibre plastic covered | MK032100 | Installation space | 02.04
Pipe | 02 Second floor | ML-Copper pipes length 5 m 35x1,5 mm-Pipe insulation 9x35 mm gray insulation thickness 9 mm-9 | X=8.07 | 0.20 m | CC= 3.23m FCL | 00 | Edge= 0.04m SSL | CC= 0.07m FFB | CC= 0.07m SSL | ins= 9.000000 mm | Dra.no: 3 | 5 | NN=7.00 m | 0 | 0 | Storey: 4 | Y=13.45 | .000 | NNUK=6.98 m | .0000 | Heat flow | Top= 3.21m FCL | 155.444 | Pipe insulation | ZP150/935 | Installation space | 02.04
Pipe | 02 Second floor | ML-Copper pipes length 5 m 35x1,5 mm-Mineral fibre plastic covered 30x35-30 | X=16.39 | 2.40 m | CC= 1.03m FCL | 00 | Edge= 2.22m SSL | CC= 2.27m FFB | CC= 2.27m SSL | ins= 30.000000 mm | Dra.no: 3 | 6 | NN=9.20 m | 0 | 100 | Storey: 4 | Y=12.92 | .000 | NNUK=9.15 m | .0000 | Heat return | Top= 0.98m FCL | 26.1138 | Fibre plastic covered | MK032100 | Installation space | 02.04
Pipe | 02 Second floor | ML-Copper pipes length 5 m 35x1,5 mm-Pipe insulation 9x35 mm gray insulation thickness 9 mm-9 | X=8.03 | 0.65 m | CC= 2.78m FCL | 00 | Edge= 0.49m SSL | CC= 0.52m FFB | CC= 0.52m SSL | ins= 9.000000 mm | Dra.no: 3 | 6 | NN=7.45 m | 1 | 0 | Storey: 4 | Y=12.31 | .000 | NNUK=7.43 m | .0000 | Heat return | Top= 2.76m FCL | 502 | Pipe insulation | ZP150/935 | Installation space | 02.04
Pipe | 02 Second floor | ML-Copper pipes length 5 m 35x1,5 mm-Mineral fibre plastic covered 30x35-30 | X=8.98 | 2.40 m | CC= 1.03m FCL | 00 | Edge= 2.22m SSL | CC= 2.27m FFB | CC= 2.27m SSL | ins= 30.000000 mm | Dra.no: 3 | 6 | NN=9.20 m | 7 | 100 | Storey: 4 | Y=12.97 | .000 | NNUK=9.15 m | .0000 | Heat return | Top= 0.98m FCL | 7366.45 | Fibre plastic covered | MK032100 | Installation space | 02.04
Pipe | 02 Second floor | ML-Copper pipes length 5 m 35x1,5 mm-Pipe insulation 9x35 mm gray insulation thickness 9 mm-9 | X=8.03 | 0.10 m | CC= 3.33m FCL | 00 | Edge= -0.06m SSL | CC= -0.03m FFB | CC= -0.03m SSL | ins= 9.000000 mm | Dra.no: 3 | 6 | NN=6.90 m | 0 | 0 | Storey: 4 | Y=12.36 | .000 | NNUK=6.88 m | .0000 | Heat return | Top= 3.31m FCL | 483.503 | Pipe insulation | ZP150/935 | Installation space | 02.04
Pipe | 02 Second floor | ML-Copper pipes length 5 m 35x1,5 mm-Mineral fibre plastic covered 30x35-30 | X=8.93 | 2.40 m | CC= 1.03m FCL | 00 | Edge= 2.22m SSL | CC= 2.27m FFB | CC= 2.27m SSL | ins= 30.000000 mm | Dra.no: 3 | 6 | NN=9.20 m | 2 | 100 | Storey: 4 | Y=14.92 | .000 | NNUK=9.15 m | .0000 | Heat return | Top= 0.98m FCL | 1902.06 | Fibre plastic covered | MK032100 | Installation space | 02.04
Pipe | 02 Second floor | ML-Copper pipes length 5 m 35x1,5 mm-Mineral fibre plastic covered 30x35-30 | X=8.16 | 2.40 m | CC= 1.03m FCL | 00 | Edge= 2.22m SSL | CC= 2.27m FFB | CC= 2.27m SSL | ins= 30.000000 mm | Dra.no: 3 | 6 | NN=9.20 m | 1 | 100 | Storey: 4 | Y=14.97 | .000 | NNUK=9.15 m | .0000 | Heat return | Top= 0.98m FCL | 720.673 | Fibre plastic covered | MK032100 | Installation space | 02.04
Pipe | 02 Second floor | ML-Copper pipes length 5 m 35x1,5 mm-Mineral fibre plastic covered 30x35-30 | X=8.12 | 1.90 m | CC= 1.53m FCL | 00 | Edge= 1.72m SSL | CC= 1.77m FFB | CC= 1.77m SSL | ins= 30.000000 mm | Dra.no: 3 | 6 | NN=8.70 m | 0 | 100 | Storey: 4 | Y=14.97 | .000 | NNUK=8.65 m | .0000 | Heat return | Top= 1.48m FCL | 452 | Fibre plastic covered | MK032100 | Installation space | 02.04
Pipe | 02 Second floor | ML-Copper pipes length 5 m 35x1,5 mm-Mineral fibre plastic covered 30x35-30 | X=16.34 | 0.60 m | CC= 2.83m FCL | 00 | Edge= 0.42m SSL | CC= 0.47m FFB | CC= 0.47m SSL | ins= 30.000000 mm | Dra.no: 3 | 5 | NN=7.40 m | 0 | 100 | Storey: 4 | Y=12.85 | .000 | NNUK=7.35 m | .0000 | Heat flow | Top= 2.78m FCL | 289.214 | Fibre plastic covered | MK032100 | Installation space | 02.04

# IfcFlowSegment: SS091209008 (4)
In: 02 Second floor
Type - Description: Copper pipes length 5 m 42x1,5 mm; ApplicableOccurrence: Copper; PredefinedType: RIGIDSEGMENT
