Properties of the parts of a building model (IFC2X3), part 8 of 14

# IfcFlowSegment: HT12/0319 (36)
Name | In | Mtg. Below Ceiling ref Top | Above Sea Level ref. Center | Y | Mtg. Above Slab ref Bottom | Mounting Height | Model Number | Above Sea Level ref. Bottom | Pset_DDS, Length | Floor number | Mtg. above Finished Floor ref Center | X | Mtg. Below Ceiling ref Center | Mtg. Above Slab ref Center | Pset_FlowSegmentPipeSegment, Length (mm)
Pipe | 01 First floor | Top= -0.06m FCL | NN=3.27 m | Y=13.56 | Edge= -0.12m SSL | -0.03 m | Dra.no: 2 | NNUK=3.18 m | 0 | Storey: 3 | CC= -0.03m FFB | X=22.25 | CC= 3.33m FCL | CC= -0.03m SSL | 39.3098
Pipe | 01 First floor | Top= -0.00m FCL | NN=3.85 m | Y=14.64 | Edge= 0.52m SSL | 0.55 m | Dra.no: 2 | NNUK=3.82 m | 0 | Storey: 3 | CC= 0.55m FFB | X=22.22 | CC= 2.75m FCL | CC= 0.55m SSL | 98.6176
Pipe | 01 First floor | Top= 0.00m FCL | NN=3.36 m | Y=14.64 | Edge= 0.03m SSL | 0.06 m | Dra.no: 2 | NNUK=3.33 m | 0 | Storey: 3 | CC= 0.06m FFB | X=22.25 | CC= 3.24m FCL | CC= 0.06m SSL | 459.843
Pipe | 01 First floor | Top= -0.06m FCL | NN=3.28 m | Y=14.58 | Edge= -0.11m SSL | -0.02 m | Dra.no: 2 | NNUK=3.19 m | 0 | Storey: 3 | CC= -0.02m FFB | X=22.25 | CC= 3.32m FCL | CC= -0.02m SSL | 81.7341
Pipe | 01 First floor | Top= 2.85m FCL | NN=3.85 m | Y=15.17 | Edge= 0.39m SSL | 0.55 m | Dra.no: 2 | NNUK=3.82 m | 0 | Storey: 3 | CC= 0.42m FFB | X=23.21 | CC= 2.88m FCL | CC= 0.42m SSL | 10.2818 | Pset_DDS - Room tekst: wc; Room number: 01.11
Pipe | 01 First floor | Top= 3.33m FCL | NN=3.38 m | Y=15.20 | Edge= -0.08m SSL | 0.08 m | Dra.no: 2 | NNUK=3.35 m | 0 | Storey: 3 | CC= -0.05m FFB | X=23.21 | CC= 3.35m FCL | CC= -0.05m SSL | 444.535 | Pset_DDS - Room tekst: Hallway; Room number: 01.01
Pipe | 01 First floor | Top= 3.41m FCL | NN=3.23 m | Y=15.20 | Edge= -0.29m SSL | -0.07 m | Dra.no: 2 | NNUK=3.14 m | 0 | Storey: 3 | CC= -0.20m FFB | X=23.08 | CC= 3.50m FCL | CC= -0.20m SSL | 173.731 | Pset_DDS - Room tekst: Hallway; Room number: 01.01
Pipe | 01 First floor | Top= 3.49m FCL | NN=3.21 m | Y=15.20 | Edge= -0.24m SSL | -0.09 m | Dra.no: 2 | NNUK=3.19 m | 1 | Storey: 3 | CC= -0.22m FFB | X=22.28 | CC= 3.52m FCL | CC= -0.22m SSL | 775.861 | Pset_DDS - Room tekst: Hallway; Room number: 01.01
Pipe | 01 First floor | Top= -0.00m FCL | NN=3.21 m | Y=15.06 | Edge= -0.11m SSL | -0.09 m | Dra.no: 2 | NNUK=3.19 m | 0 | Storey: 3 | CC= -0.09m FFB | X=22.25 | CC= 3.39m FCL | CC= -0.09m SSL | 108.929
Pipe | 01 First floor | Top= 2.85m FCL | NN=3.85 m | Y=12.03 | Edge= 0.39m SSL | 0.55 m | Dra.no: 2 | NNUK=3.82 m | 0 | Storey: 3 | CC= 0.42m FFB | X=23.21 | CC= 2.88m FCL | CC= 0.42m SSL | 5.45199 | Pset_DDS - Room tekst: wc; Room number: 01.10
Pipe | 01 First floor | Top= 3.50m FCL | NN=3.20 m | Y=12.00 | Edge= -0.25m SSL | -0.10 m | Dra.no: 2 | NNUK=3.18 m | 1 | Storey: 3 | CC= -0.23m FFB | X=23.21 | CC= 3.53m FCL | CC= -0.23m SSL | 618.465 | Pset_DDS - Room tekst: Restaurant; Room number: 01.03
Pipe | 01 First floor | Top= 3.54m FCL | NN=3.17 m | Y=11.33 | Edge= -0.29m SSL | -0.13 m | Dra.no: 2 | NNUK=3.14 m | 1 | Storey: 3 | CC= -0.26m FFB | X=23.21 | CC= 3.56m FCL | CC= -0.26m SSL | 636.599 | Pset_DDS - Room tekst: Restaurant; Room number: 01.03
Pipe | 01 First floor | Top= 3.54m FCL | NN=3.16 m | Y=11.28 | Edge= -0.29m SSL | -0.14 m | Dra.no: 2 | NNUK=3.14 m | 0 | Storey: 3 | CC= -0.27m FFB | X=23.24 | CC= 3.57m FCL | CC= -0.27m SSL | 39.3098 | Pset_DDS - Room tekst: Restaurant; Room number: 01.03
Pipe | 01 First floor | Top= -0.00m FCL | NN=3.85 m | Y=12.56 | Edge= 0.52m SSL | 0.55 m | Dra.no: 2 | NNUK=3.82 m | 0 | Storey: 3 | CC= 0.55m FFB | X=22.22 | CC= 2.75m FCL | CC= 0.55m SSL | 98.6176

# IfcFlowSegment: HT12/0619 (54)
Type - Description: HT sewer pipe DN 100; ApplicableOccurrence: Drainage; PredefinedType: RIGIDSEGMENT
Type - Pset_ManufacturerTypeInformation - ArticleNumber: HT12/0619; ModelReference: HT sewer pipe DN 100; Manufacturer: DDS
Type - Pset_PipeSegmentTypeCommon - NominalDiameter: 100; InnerDiameter: 104.6; OuterDiameter: 110
Material: ML-HT sewer pipe DN 100
Pset_DDS - Pressure drop: 0 Pa; Drain slope: 1:100; Medium: Sewer; Manufacturer: DDS; Flowsegment thickness: x2.7; Ins thickness: ins= 0.000000 mm; Drain slope (%): 1.0 %; Outside dimension: 109.999999; Drain slope (\X\B0): 0.6\X\B0; Product: HT sewer pipe DN 100; Layer number: 178; Main string number: 00; Width: 100; Dimension DN: 100; Project name: OpenBIM; Product Number: HT12/0619; Insulation WSVO: 0; Insulation k-value: 0; Drain Qww: Qww=0.00 l/s; Flow (l/h): 0.000000 l/h; Part number: .000; Sub string number: .0000; Temperature: 0.00 \X\B0C; Drain DU: DU=0.00 l/s; Building Part: Building: 0; Peak flow (l/s): 0.00 l/s; Flow (l/s): 0.00 l/s; Abs. pressure: 0.0 Pa; Velocity: 0.00 m/s
AC_Pset_RenovationAndPhasing - Renovation Status: Existing
Name | In | Mtg. Above Slab ref Center | Above Sea Level ref. Center | Above Sea Level ref. Bottom | Mounting Height | Mtg. Below Ceiling ref Center | Y | Model Number | Mtg. Above Slab ref Bottom | Pset_DDS, Length | Floor number | Mtg. Below Ceiling ref Top | X | Mtg. above Finished Floor ref Center | Pset_FlowSegmentPipeSegment, Length (mm)
Pipe | 00 Ground floor | CC= 0.02m SSL | NN=-0.18 m | NNUK=-0.36 m | 0.02 m | CC= 3.48m FCL | Y=12.47 | Dra.no: 1 | Edge= -0.16m SSL | 0 | Storey: 2 | Top= -0.12m FCL | X=18.69 | CC= 0.02m FFB | 63.6347
Pipe | 00 Ground floor | CC= 0.23m SSL | NN=0.03 m | NNUK=-0.02 m | 0.23 m | CC= 3.27m FCL | Y=13.61 | Dra.no: 1 | Edge= 0.18m SSL | 0 | Storey: 2 | Top= -0.00m FCL | X=18.75 | CC= 0.23m FFB | 67.5792
Pipe | 00 Ground floor | CC= 0.11m SSL | NN=-0.09 m | NNUK=-0.14 m | 0.11 m | CC= 3.39m FCL | Y=13.61 | Dra.no: 1 | Edge= 0.06m SSL | 0 | Storey: 2 | Top= 0.00m FCL | X=18.69 | CC= 0.11m FFB | 60.2867
Pipe | 00 Ground floor | CC= 0.03m SSL | NN=-0.17 m | NNUK=-0.35 m | 0.03 m | CC= 3.47m FCL | Y=13.55 | Dra.no: 1 | Edge= -0.15m SSL | 0 | Storey: 2 | Top= -0.12m FCL | X=18.69 | CC= 0.03m FFB | 56.3381
Pipe | 00 Ground floor | CC= 0.23m SSL | NN=0.03 m | NNUK=-0.02 m | 0.23 m | CC= 3.27m FCL | Y=14.67 | Dra.no: 1 | Edge= 0.18m SSL | 0 | Storey: 2 | Top= -0.00m FCL | X=18.75 | CC= 0.23m FFB | 67.5792
Pipe | 00 Ground floor | CC= 0.11m SSL | NN=-0.09 m | NNUK=-0.14 m | 0.11 m | CC= 3.39m FCL | Y=14.67 | Dra.no: 1 | Edge= 0.06m SSL | 0 | Storey: 2 | Top= 0.00m FCL | X=18.69 | CC= 0.11m FFB | 56.5435
Pipe | 00 Ground floor | CC= -0.04m SSL | NN=-0.24 m | NNUK=-0.42 m | -0.04 m | CC= 3.54m FCL | Y=14.54 | Dra.no: 1 | Edge= -0.22m SSL | 0 | Storey: 2 | Top= -0.12m FCL | X=18.69 | CC= -0.04m FFB | 155.444
Pipe | 00 Ground floor | CC= -0.07m SSL | NN=-0.27 m | NNUK=-0.32 m | -0.07 m | CC= 3.57m FCL | Y=13.59 | Dra.no: 1 | Edge= -0.12m SSL | 1 | Storey: 2 | Top= -0.00m FCL | X=18.69 | CC= -0.07m FFB | 908.224
Pipe | 00 Ground floor | CC= -0.08m SSL | NN=-0.28 m | NNUK=-0.33 m | -0.08 m | CC= 3.58m FCL | Y=12.51 | Dra.no: 1 | Edge= -0.13m SSL | 1 | Storey: 2 | Top= -0.00m FCL | X=18.69 | CC= -0.08m FFB | 866.495
Pipe | 00 Ground floor | CC= -0.09m SSL | NN=-0.29 m | NNUK=-0.34 m | -0.09 m | CC= 3.59m FCL | Y=11.27 | Dra.no: 1 | Edge= -0.14m SSL | 1 | Storey: 2 | Top= 3.54m FCL | X=18.69 | CC= -0.09m FFB | 1019.94 | Pset_DDS - Room tekst: Entrance; Room number: 00.01
Pipe | 00 Ground floor | CC= -0.13m SSL | NN=-0.33 m | NNUK=-0.38 m | -0.13 m | CC= 3.63m FCL | Y=11.21 | Dra.no: 1 | Edge= -0.18m SSL | 3 | Storey: 2 | Top= 3.58m FCL | X=22.19 | CC= -0.13m FFB | 3431.13 | Pset_DDS - Room tekst: Entrance; Room number: 00.01
Pipe | 00 Ground floor | CC= -0.09m SSL | NN=-0.29 m | NNUK=-0.34 m | -0.09 m | CC= 3.59m FCL | Y=14.60 | Dra.no: 1 | Edge= -0.14m SSL | 0 | Storey: 2 | Top= -0.00m FCL | X=22.25 | CC= -0.09m FFB | 416.076
Pipe | 00 Ground floor | CC= -0.10m SSL | NN=-0.30 m | NNUK=-0.35 m | -0.10 m | CC= 3.60m FCL | Y=14.15 | Dra.no: 1 | Edge= -0.15m SSL | 0 | Storey: 2 | Top= -0.00m FCL | X=22.25 | CC= -0.10m FFB | 294.509
Pipe | 00 Ground floor | CC= -0.10m SSL | NN=-0.30 m | NNUK=-0.35 m | -0.10 m | CC= 3.60m FCL | Y=13.59 | Dra.no: 1 | Edge= -0.15m SSL | 0 | Storey: 2 | Top= -0.00m FCL | X=22.25 | CC= -0.10m FFB | 349.178
Pipe | 00 Ground floor | CC= -0.11m SSL | NN=-0.31 m | NNUK=-0.36 m | -0.11 m | CC= 3.61m FCL | Y=13.03 | Dra.no: 1 | Edge= -0.16m SSL | 0 | Storey: 2 | Top= -0.00m FCL | X=22.25 | CC= -0.11m FFB | 401.811
Pipe | 00 Ground floor | CC= -0.11m SSL | NN=-0.31 m | NNUK=-0.36 m | -0.11 m | CC= 3.61m FCL | Y=12.54 | Dra.no: 1 | Edge= -0.16m SSL | 0 | Storey: 2 | Top= -0.00m FCL | X=22.25 | CC= -0.11m FFB | 271.574
Pipe | 00 Ground floor | CC= -0.13m SSL | NN=-0.33 m | NNUK=-0.38 m | -0.13 m | CC= 3.63m FCL | Y=11.28 | Dra.no: 1 | Edge= -0.18m SSL | 1 | Storey: 2 | Top= 3.58m FCL | X=22.25 | CC= -0.13m FFB | 1114.7 | Pset_DDS - Room tekst: Entrance; Room number: 00.01
Pipe | 00 Ground floor | CC= -0.14m SSL | NN=-0.34 m | NNUK=-0.39 m | -0.14 m | CC= 3.64m FCL | Y=11.21 | Dra.no: 1 | Edge= -0.19m SSL | 1 | Storey: 2 | Top= 3.59m FCL | X=23.22 | CC= -0.14m FFB | 853.474 | Pset_DDS - Room tekst: Entrance; Room number: 00.01
Pipe | 00 Ground floor | CC= -0.33m SSL | NN=-0.40 m | NNUK=-0.45 m | -0.20 m | CC= 3.63m FCL | Y=11.21 | Dra.no: 1 | Edge= -0.38m SSL | 6 | Storey: 2 | Top= 3.58m FCL | X=29.58 | CC= -0.33m FFB | 6208.96 | Pset_DDS - Room tekst: Shaft; Room number: 00.27
Pipe | 00 Ground floor | CC= 0.23m SSL | NN=0.03 m | NNUK=-0.02 m | 0.23 m | CC= 3.27m FCL | Y=13.05 | Dra.no: 1 | Edge= 0.18m SSL | 0 | Storey: 2 | Top= -0.00m FCL | X=22.31 | CC= 0.23m FFB | 71.1076
Pipe | 00 Ground floor | CC= 0.07m SSL | NN=-0.13 m | NNUK=-0.18 m | 0.07 m | CC= 3.43m FCL | Y=13.05 | Dra.no: 1 | Edge= 0.02m SSL | 0 | Storey: 2 | Top= 0.00m FCL | X=22.25 | CC= 0.07m FFB | 98.6176
Pipe | 00 Ground floor | CC= -0.01m SSL | NN=-0.21 m | NNUK=-0.39 m | -0.01 m | CC= 3.51m FCL | Y=12.99 | Dra.no: 1 | Edge= -0.19m SSL | 0 | Storey: 2 | Top= -0.12m FCL | X=22.25 | CC= -0.01m FFB | 60.2867
Pipe | 00 Ground floor | CC= 0.23m SSL | NN=0.03 m | NNUK=-0.02 m | 0.23 m | CC= 3.27m FCL | Y=14.17 | Dra.no: 1 | Edge= 0.18m SSL | 0 | Storey: 2 | Top= -0.00m FCL | X=22.31 | CC= 0.23m FFB | 62.9461
Pipe | 00 Ground floor | CC= 0.08m SSL | NN=-0.12 m | NNUK=-0.17 m | 0.08 m | CC= 3.42m FCL | Y=14.17 | Dra.no: 1 | Edge= 0.03m SSL | 0 | Storey: 2 | Top= 0.00m FCL | X=22.25 | CC= 0.08m FFB | 92.6546
Pipe | 00 Ground floor | CC= -0.00m SSL | NN=-0.20 m | NNUK=-0.38 m | -0.00 m | CC= 3.50m FCL | Y=14.11 | Dra.no: 1 | Edge= -0.18m SSL | 0 | Storey: 2 | Top= -0.12m FCL | X=22.25 | CC= -0.00m FFB | 53.0373
Pipe | 00 Ground floor | CC= 0.23m SSL | NN=0.03 m | NNUK=-0.02 m | 0.23 m | CC= 3.27m FCL | Y=12.53 | Dra.no: 1 | Edge= 0.18m SSL | 0 | Storey: 2 | Top= -0.00m FCL | X=18.75 | CC= 0.23m FFB | 67.5792
Pipe | 00 Ground floor | CC= 0.10m SSL | NN=-0.10 m | NNUK=-0.15 m | 0.10 m | CC= 3.40m FCL | Y=12.53 | Dra.no: 1 | Edge= 0.05m SSL | 0 | Storey: 2 | Top= 0.00m FCL | X=18.69 | CC= 0.10m FFB | 65.9134
Pipe | 01 First floor | CC= 0.23m SSL | NN=3.53 m | NNUK=3.48 m | 0.23 m | CC= 3.07m FCL | Y=13.05 | Dra.no: 2 | Edge= 0.18m SSL | 0 | Storey: 3 | Top= -0.00m FCL | X=22.31 | CC= 0.23m FFB | 49.7015
Pipe | 01 First floor | CC= 0.07m SSL | NN=3.37 m | NNUK=3.32 m | 0.07 m | CC= 3.23m FCL | Y=13.05 | Dra.no: 2 | Edge= 0.02m SSL | 0 | Storey: 3 | Top= 0.00m FCL | X=22.25 | CC= 0.07m FFB | 98.6176
Pipe | 01 First floor | CC= -0.01m SSL | NN=3.29 m | NNUK=3.11 m | -0.01 m | CC= 3.31m FCL | Y=12.99 | Dra.no: 2 | Edge= -0.19m SSL | 0 | Storey: 3 | Top= -0.12m FCL | X=22.25 | CC= -0.01m FFB | 60.2867
Pipe | 01 First floor | CC= 0.23m SSL | NN=3.53 m | NNUK=3.48 m | 0.23 m | CC= 3.07m FCL | Y=14.17 | Dra.no: 2 | Edge= 0.18m SSL | 0 | Storey: 3 | Top= -0.00m FCL | X=22.31 | CC= 0.23m FFB | 41.541
Pipe | 01 First floor | CC= 0.08m SSL | NN=3.38 m | NNUK=3.33 m | 0.08 m | CC= 3.22m FCL | Y=14.17 | Dra.no: 2 | Edge= 0.03m SSL | 0 | Storey: 3 | Top= 0.00m FCL | X=22.25 | CC= 0.08m FFB | 92.6546
Pipe | 01 First floor | CC= -0.00m SSL | NN=3.30 m | NNUK=3.12 m | -0.00 m | CC= 3.30m FCL | Y=14.11 | Dra.no: 2 | Edge= -0.18m SSL | 0 | Storey: 3 | Top= -0.12m FCL | X=22.25 | CC= -0.00m FFB | 53.0373
Pipe | 01 First floor | CC= 0.23m SSL | NN=3.53 m | NNUK=3.48 m | 0.23 m | CC= 3.07m FCL | Y=12.53 | Dra.no: 2 | Edge= 0.18m SSL | 0 | Storey: 3 | Top= -0.00m FCL | X=18.75 | CC= 0.23m FFB | 45.7759
Pipe | 01 First floor | CC= 0.10m SSL | NN=3.40 m | NNUK=3.35 m | 0.10 m | CC= 3.20m FCL | Y=12.53 | Dra.no: 2 | Edge= 0.05m SSL | 0 | Storey: 3 | Top= 0.00m FCL | X=18.69 | CC= 0.10m FFB | 65.9134
Pipe | 01 First floor | CC= -0.26m SSL | NN=3.17 m | NNUK=3.12 m | -0.13 m | CC= 3.56m FCL | Y=11.21 | Dra.no: 2 | Edge= -0.31m SSL | 3 | Storey: 3 | Top= 3.51m FCL | X=22.19 | CC= -0.26m FFB | 3431.13 | Pset_DDS - Room tekst: Restaurant; Room number: 01.03
Pipe | 01 First floor | CC= -0.09m SSL | NN=3.21 m | NNUK=3.16 m | -0.09 m | CC= 3.39m FCL | Y=14.60 | Dra.no: 2 | Edge= -0.14m SSL | 0 | Storey: 3 | Top= -0.00m FCL | X=22.25 | CC= -0.09m FFB | 416.076
Pipe | 01 First floor | CC= -0.10m SSL | NN=3.20 m | NNUK=3.15 m | -0.10 m | CC= 3.40m FCL | Y=14.15 | Dra.no: 2 | Edge= -0.15m SSL | 0 | Storey: 3 | Top= -0.00m FCL | X=22.25 | CC= -0.10m FFB | 294.509
Pipe | 01 First floor | CC= -0.10m SSL | NN=3.20 m | NNUK=3.15 m | -0.10 m | CC= 3.40m FCL | Y=13.59 | Dra.no: 2 | Edge= -0.15m SSL | 0 | Storey: 3 | Top= -0.00m FCL | X=22.25 | CC= -0.10m FFB | 349.178
Pipe | 01 First floor | CC= -0.11m SSL | NN=3.19 m | NNUK=3.14 m | -0.11 m | CC= 3.41m FCL | Y=13.03 | Dra.no: 2 | Edge= -0.16m SSL | 0 | Storey: 3 | Top= -0.00m FCL | X=22.25 | CC= -0.11m FFB | 401.811
Pipe | 01 First floor | CC= -0.11m SSL | NN=3.19 m | NNUK=3.14 m | -0.11 m | CC= 3.41m FCL | Y=12.54 | Dra.no: 2 | Edge= -0.16m SSL | 0 | Storey: 3 | Top= -0.00m FCL | X=22.25 | CC= -0.11m FFB | 271.574
Pipe | 01 First floor | CC= -0.26m SSL | NN=3.17 m | NNUK=3.12 m | -0.13 m | CC= 3.56m FCL | Y=11.28 | Dra.no: 2 | Edge= -0.31m SSL | 1 | Storey: 3 | Top= 3.51m FCL | X=22.25 | CC= -0.26m FFB | 1114.7 | Pset_DDS - Room tekst: Restaurant; Room number: 01.03
Pipe | 01 First floor | CC= -0.27m SSL | NN=3.16 m | NNUK=3.11 m | -0.14 m | CC= 3.57m FCL | Y=11.21 | Dra.no: 2 | Edge= -0.32m SSL | 1 | Storey: 3 | Top= 3.52m FCL | X=23.22 | CC= -0.27m FFB | 853.474 | Pset_DDS - Room tekst: Restaurant; Room number: 01.03
Pipe | 01 First floor | CC= -0.20m SSL | NN=3.10 m | NNUK=3.05 m | -0.20 m | CC= 3.50m FCL | Y=11.21 | Dra.no: 2 | Edge= -0.25m SSL | 6 | Storey: 3 | Top= -0.00m FCL | X=29.58 | CC= -0.20m FFB | 6208.96
Pipe | 01 First floor | CC= 0.02m SSL | NN=3.32 m | NNUK=3.14 m | 0.02 m | CC= 3.28m FCL | Y=12.47 | Dra.no: 2 | Edge= -0.16m SSL | 0 | Storey: 3 | Top= -0.12m FCL | X=18.69 | CC= 0.02m FFB | 63.6347
Pipe | 01 First floor | CC= 0.23m SSL | NN=3.53 m | NNUK=3.48 m | 0.23 m | CC= 3.07m FCL | Y=13.61 | Dra.no: 2 | Edge= 0.18m SSL | 0 | Storey: 3 | Top= -0.00m FCL | X=18.75 | CC= 0.23m FFB | 45.7759
Pipe | 01 First floor | CC= 0.11m SSL | NN=3.41 m | NNUK=3.36 m | 0.11 m | CC= 3.19m FCL | Y=13.61 | Dra.no: 2 | Edge= 0.06m SSL | 0 | Storey: 3 | Top= 0.00m FCL | X=18.69 | CC= 0.11m FFB | 60.5011
Pipe | 01 First floor | CC= 0.03m SSL | NN=3.33 m | NNUK=3.15 m | 0.03 m | CC= 3.27m FCL | Y=13.55 | Dra.no: 2 | Edge= -0.15m SSL | 0 | Storey: 3 | Top= -0.12m FCL | X=18.69 | CC= 0.03m FFB | 56.3381
Pipe | 01 First floor | CC= 0.23m SSL | NN=3.53 m | NNUK=3.48 m | 0.23 m | CC= 3.07m FCL | Y=14.67 | Dra.no: 2 | Edge= 0.18m SSL | 0 | Storey: 3 | Top= -0.00m FCL | X=18.75 | CC= 0.23m FFB | 45.7759
Pipe | 01 First floor | CC= 0.11m SSL | NN=3.41 m | NNUK=3.36 m | 0.11 m | CC= 3.19m FCL | Y=14.67 | Dra.no: 2 | Edge= 0.06m SSL | 0 | Storey: 3 | Top= 0.00m FCL | X=18.69 | CC= 0.11m FFB | 56.5435
Pipe | 01 First floor | CC= -0.04m SSL | NN=3.26 m | NNUK=3.08 m | -0.04 m | CC= 3.34m FCL | Y=14.54 | Dra.no: 2 | Edge= -0.22m SSL | 0 | Storey: 3 | Top= -0.12m FCL | X=18.69 | CC= -0.04m FFB | 155.444
Pipe | 01 First floor | CC= -0.07m SSL | NN=3.23 m | NNUK=3.18 m | -0.07 m | CC= 3.37m FCL | Y=13.59 | Dra.no: 2 | Edge= -0.12m SSL | 1 | Storey: 3 | Top= -0.00m FCL | X=18.69 | CC= -0.07m FFB | 908.224
Pipe | 01 First floor | CC= -0.08m SSL | NN=3.22 m | NNUK=3.17 m | -0.08 m | CC= 3.38m FCL | Y=12.51 | Dra.no: 2 | Edge= -0.13m SSL | 1 | Storey: 3 | Top= -0.00m FCL | X=18.69 | CC= -0.08m FFB | 866.495
Pipe | 01 First floor | CC= -0.22m SSL | NN=3.21 m | NNUK=3.16 m | -0.09 m | CC= 3.52m FCL | Y=11.27 | Dra.no: 2 | Edge= -0.27m SSL | 1 | Storey: 3 | Top= 3.47m FCL | X=18.69 | CC= -0.22m FFB | 1019.94 | Pset_DDS - Room tekst: Restaurant; Room number: 01.03

# IfcFlowSegment: HT12/0719 (8)
Type - Description: HT sewer pipe DN 125; ApplicableOccurrence: Drainage; PredefinedType: RIGIDSEGMENT
Type - Pset_ManufacturerTypeInformation - ArticleNumber: HT12/0719; ModelReference: HT sewer pipe DN 125; Manufacturer: DDS
Type - Pset_PipeSegmentTypeCommon - NominalDiameter: 125; InnerDiameter: 118.8; OuterDiameter: 125
Material: ML-HT sewer pipe DN 125
Pset_DDS - Pressure drop: 0 Pa; Drain slope: 1:100; Outside dimension: 125.000003; Medium: Sewer; Manufacturer: DDS; X: X=29.65; Dimension DN: 125; Width: 125; Product: HT sewer pipe DN 125; Ins thickness: ins= 0.000000 mm; Drain slope (%): 1.0 %; Drain slope (\X\B0): 0.6\X\B0; Flowsegment thickness: x3.1; Layer number: 178; Project name: OpenBIM; Product Number: HT12/0719; Insulation WSVO: 0; Insulation k-value: 0; Drain Qww: Qww=0.00 l/s; Flow (l/h): 0.000000 l/h; Sub string number: .0000; Temperature: 0.00 \X\B0C; Drain DU: DU=0.00 l/s; Building Part: Building: 0; Peak flow (l/s): 0.00 l/s; Flow (l/s): 0.00 l/s; Abs. pressure: 0.0 Pa; Velocity: 0.00 m/s
AC_Pset_RenovationAndPhasing - Renovation Status: Existing
Name | In | Pset_FlowSegmentPipeSegment, Length (mm) | Mtg. Above Slab ref Bottom | Mounting Height | Mtg. Below Ceiling ref Top | Main string number | Mtg. above Finished Floor ref Center | Above Sea Level ref. Bottom | Mtg. Above Slab ref Center | Mtg. Below Ceiling ref Center | Above Sea Level ref. Center | Model Number | Pset_DDS, Length | Floor number | Part number | Y
01.0000.00 | -01 Foundation | 10040.6 | Edge= -0.06m SSL | 0.00 m | Top= -0.00m FCL | 01 | CC= 0.00m FFB | NNUK=-1.06 m | CC= 0.00m SSL | CC= 0.67m FCL | NN=-1.00 m | Dra.no: 0 | 10 | Storey: 1 | .000 | Y=1.03 | Group: Sewer
01.0000.00 | -01 Foundation | 99.9919 | Edge= -0.09m SSL | 0.12 m | Top= -0.15m FCL | 01 | CC= 0.12m FFB | NNUK=-1.09 m | CC= 0.12m SSL | CC= 0.55m FCL | NN=-0.88 m | Dra.no: 0 | 0 | Storey: 1 | .000 | Y=11.12 | Group: Sewer
01.0000.00 | -01 Foundation | 503.546 | Edge= 0.18m SSL | 0.25 m | Top= 0.00m FCL | 01 | CC= 0.25m FFB | NNUK=-0.82 m | CC= 0.25m SSL | CC= 0.42m FCL | NN=-0.75 m | Dra.no: 0 | 1 | Storey: 1 | .000 | Y=11.21 | Group: Sewer
Pipe | 00 Ground floor | 3336 | Edge= -0.33m SSL | -0.14 m | Top= 3.50m FCL | 00 | CC= -0.27m FFB | NNUK=-0.40 m | CC= -0.27m SSL | CC= 3.57m FCL | NN=-0.34 m | Dra.no: 1 | 3 | Storey: 2 | .000 | Y=11.21 | Pset_DDS - Room number: 00.27; Room tekst: Shaft
Pipe | 00 Ground floor | 27 | Edge= -0.49m SSL | -0.30 m | Top= 3.67m FCL | 00 | CC= -0.43m FFB | NNUK=-0.56 m | CC= -0.43m SSL | CC= 3.73m FCL | NN=-0.50 m | Dra.no: 1 | -0 | Storey: 2 | .000 | Y=11.21 | Pset_DDS - Room number: 00.27; Room tekst: Shaft
Pipe | 01 First floor | 3336 | Edge= -0.20m SSL | -0.14 m | Top= 0.00m FCL | 00 | CC= -0.14m FFB | NNUK=3.10 m | CC= -0.14m SSL | CC= 3.44m FCL | NN=3.16 m | Dra.no: 2 | 3 | Storey: 3 | .000 | Y=11.21
Pipe | 02 Second floor | 3550 | Edge= -0.36m SSL | -0.30 m | Top= 0.00m FCL | 00 | CC= -0.30m FFB | NNUK=6.44 m | CC= -0.30m SSL | CC= 3.60m FCL | NN=6.50 m | Dra.no: 3 | 4 | Storey: 4 | .002 | Y=11.21
Pipe | 03. Roof | 99.9919 | Edge= -0.31m SSL | -0.25 m | Top= 0.00m FCL | 00 | CC= -0.25m FFB | NNUK=9.99 m | CC= -0.25m SSL | CC= 3.62m FCL | NN=10.05 m | Dra.no: 4 | 0 | Storey: 5 | .010 | Y=11.21

# IfcFlowSegment: QL-030916-003 (15)
Type - Description: Cable tray 300 mm; ApplicableOccurrence: Ladder tray; PredefinedType: CABLELADDERSEGMENT
Type - Pset_ManufacturerTypeInformation - ArticleNumber: QL-030916-003; ModelReference: Cable tray 300 mm; Manufacturer: DDS
Type - Pset_CableCarrierSegmentTypeCableLadderSegment - NominalLength: 426.956 mm; NominalWidth: 300 mm; NominalHeight: 55 mm
Material: IFC Building Material
Pset_DDS - Dimension DN: 300 x 55 mm; Manufacturer: DDS; Step Distance: 300 mm; Side Piece Width: 22 mm; Bar Height: 18 mm; Bracket Dimension: 0 mm; Bracket Depth Horizontal: 0 mm; Bracket Depth Vertical: 0 mm; Bracket Width Vertical: 0 mm; Layer number: 42; Bracket Producer Type: 00; Width: 300; Project name: OpenBIM; Product: Cable tray 300 mm; Height: 55; Flowsegment thickness: x0.0; Product Number: QL-030916-003; Bar Width: 34 mm; Building Part: Building: 0
Pset_ElectricalCostData - CostCodeValue: L-030916-003; SystemCodeValue: 42; ProductCodeValue: WP2.2; Location: NOR; ProductCodeName: NS3420; CostCodeName: Eldata Kode; SystemCodeName: NS3451
AC_Pset_RenovationAndPhasing - Renovation Status: Existing
Name | In | Y | Mtg. Below Ceiling ref Top | Mounting Height | Model Number | Length | Floor number | Mtg. above Finished Floor ref Center | Room tekst | Mtg. Above Slab ref Bottom | Mtg. Below Ceiling ref Center | Above Sea Level ref. Bottom | Room number | X | Mtg. Above Slab ref Center
Ladder | 00 Ground floor | Y=17.45 | Top= 0.49m FCL | 2.75 m | Dra.no: 1 | 1 | Storey: 2 | CC= 2.75m FFB | Hallway | Edge= 2.75m SSL | CC= 0.55m FCL | NNUK=2.55 m | 00.03 | X=24.23 | CC= 2.75m SSL
Ladder | 00 Ground floor | Y=16.66 | Top= 0.49m FCL | 2.75 m | Dra.no: 1 | 16 | Storey: 2 | CC= 2.75m FFB | Hallway | Edge= 2.75m SSL | CC= 0.55m FCL | NNUK=2.55 m | 00.03 | X=24.03 | CC= 2.75m SSL
Ladder | 00 Ground floor | Y=10.40 | Top= 0.63m FCL | 2.75 m | Dra.no: 1 | 0 | Storey: 2 | CC= 2.62m FFB | FB | Edge= 2.62m SSL | CC= 0.68m FCL | NNUK=2.55 m | 00.15 | X=30.65 | CC= 2.62m SSL
Ladder | 00 Ground floor | Y=17.65 | Top= 0.49m FCL | 2.75 m | Dra.no: 1 | 8 | Storey: 2 | CC= 2.75m FFB | Hallway | Edge= 2.75m SSL | CC= 0.55m FCL | NNUK=2.55 m | 00.03 | X=32.74 | CC= 2.75m SSL
Ladder | 00 Ground floor | Y=10.91 | Top= 0.61m FCL | 2.76 m | Dra.no: 1 | 1 | Storey: 2 | CC= 2.63m FFB | Shaft | Edge= 2.63m SSL | CC= 0.67m FCL | NNUK=2.56 m | 00.27 | X=30.65 | CC= 2.63m SSL
Ladder | 00 Ground floor | Y=10.35 | Top= 0.63m FCL | 2.75 m | Dra.no: 1 | 7 | Storey: 2 | CC= 2.62m FFB | Director office | Edge= 2.62m SSL | CC= 0.68m FCL | NNUK=2.55 m | 00.25 | X=32.94 | CC= 2.62m SSL
Ladder | 00 Ground floor | Y=10.15 | Top= 0.63m FCL | 2.75 m | Dra.no: 1 | 2 | Storey: 2 | CC= 2.62m FFB | FB | Edge= 2.62m SSL | CC= 0.68m FCL | NNUK=2.55 m | 00.15 | X=30.90 | CC= 2.62m SSL
Ladder | 00 Ground floor | Y=10.15 | Top= 0.63m FCL | 2.75 m | Dra.no: 1 | 0 | Storey: 2 | CC= 2.62m FFB | FB | Edge= 2.62m SSL | CC= 0.68m FCL | NNUK=2.55 m | 00.15 | X=29.97 | CC= 2.62m SSL
Ladder | 01 First floor | Y=16.71 | Top= 0.58m FCL | 2.80 m | Dra.no: 2 | 16 | Storey: 3 | CC= 2.67m FFB | Hallway | Edge= 2.67m SSL | CC= 0.63m FCL | NNUK=6.10 m | 01.02 | X=24.10 | CC= 2.67m SSL
Ladder | 01 First floor | Y=16.84 | Top= 0.58m FCL | 2.80 m | Dra.no: 2 | 0 | Storey: 3 | CC= 2.67m FFB | Hallway | Edge= 2.67m SSL | CC= 0.63m FCL | NNUK=6.10 m | 01.02 | X=24.31 | CC= 2.67m SSL
Ladder | 01 First floor | Y=16.90 | Top= 0.58m FCL | 2.80 m | Dra.no: 2 | 8 | Storey: 3 | CC= 2.67m FFB | Hallway | Edge= 2.67m SSL | CC= 0.63m FCL | NNUK=6.10 m | 01.02 | X=32.15 | CC= 2.67m SSL
Ladder | 01 First floor | Y=11.51 | Top= 0.58m FCL | 2.80 m | Dra.no: 2 | 5 | Storey: 3 | CC= 2.67m FFB | Restaurant | Edge= 2.67m SSL | CC= 0.63m FCL | NNUK=6.10 m | 01.03 | X=32.35 | CC= 2.67m SSL
Ladder | 01 First floor | Y=11.31 | Top= 0.00m FCL | 2.80 m | Dra.no: 2 | 1 | Storey: 3 | CC= 2.80m FFB |  | Edge= 2.80m SSL | CC= 0.50m FCL | NNUK=6.10 m |  | X=30.85 | CC= 2.80m SSL
Ladder | 01 First floor | Y=10.91 | Top= 0.00m FCL | 2.80 m | Dra.no: 2 | 0 | Storey: 3 | CC= 2.80m FFB |  | Edge= 2.80m SSL | CC= 0.50m FCL | NNUK=6.10 m |  | X=30.65 | CC= 2.80m SSL
Ladder | 01 First floor | Y=10.91 | Top= 0.00m FCL | -0.05 m | Dra.no: 2 | 3 | Storey: 3 | CC= -0.05m FFB |  | Edge= -0.05m SSL | CC= 3.35m FCL | NNUK=3.25 m |  | X=30.65 | CC= -0.05m SSL

# IfcFlowSegment: SS091209003 (172)
Type - Description: Copper pipes length 5 m 15x1 mm; ApplicableOccurrence: Copper; PredefinedType: RIGIDSEGMENT
Type - Pset_ManufacturerTypeInformation - ArticleNumber: SS091209003; ModelReference: Copper pipes length 5 m 15x1 mm; Manufacturer: DDS
Type - Pset_PipeSegmentTypeCommon - NominalDiameter: 12; InnerDiameter: 13; OuterDiameter: 15
Pset_DDS - Flowsegment thickness: x1.0; Drain slope: 1:0; Manufacturer: DDS; Width: 12; Dimension DN: 12; Drain slope (%): 10000.0 %; Project name: OpenBIM; Insulation WSVO: 0; Insulation k-value: 0; Drain Qww: Qww=0.00 l/s; Outside dimension: 15.000000; Drain slope (\X\B0): 90.0\X\B0; Drain DU: DU=0.00 l/s; Product Number: SS091209003; Building Part: Building: 0; Product: Copper pipes length 5 m 15x1 mm
AC_Pset_RenovationAndPhasing - Renovation Status: Existing
Name | In | Material | Pset_FlowSegmentPipeSegment, Length (mm) | Mtg. Above Slab ref Center | Mounting Height | Pressure drop | Above Sea Level ref. Center | Main string number | Ins thickness | Mtg. Above Slab ref Bottom | Y | Mtg. Below Ceiling ref Center | Room tekst | Model Number | Layer number | Room number | Pset_DDS, Length | Floor number | Medium | X | Above Sea Level ref. Bottom | Flow (l/h) | Part number | Sub string number | Temperature | Mtg. Below Ceiling ref Top | Mtg. above Finished Floor ref Center | Peak flow (l/s) | Flow (l/s) | Abs. pressure | Velocity | Group | Insulation product text | Insulation product number | System Name
01.0001.00 | 00 Ground floor | ML-Copper pipes length 5 m 15x1 mm | 3069.56 | CC= 3.12m SSL | 3.00 m | 0 Pa | NN=2.80 m | 01 | ins= 0.000000 mm | Edge= 3.11m SSL | Y=20.42 | CC= 0.18m FCL | Office | Dra.no: 1 | 189 | 00.23 | 3 | Storey: 2 | Cooling return | X=35.52 | NNUK=2.79 m | 0.000000 l/h | .000 | .0001 | 0.00 \X\B0C | Top= 0.17m FCL | CC= 3.12m FFB | 0.00 l/s | 0.00 l/s | 0.0 Pa | 0.00 m/s | Cooling return
01.0001.00 | 00 Ground floor | ML-Copper pipes length 5 m 15x1 mm | 62.3047 | CC= 3.12m SSL | 3.00 m | 0 Pa | NN=2.80 m | 01 | ins= 0.000000 mm | Edge= 3.11m SSL | Y=20.40 | CC= 0.18m FCL | Office | Dra.no: 1 | 189 | 00.23 | 0 | Storey: 2 | Cooling return | X=38.61 | NNUK=2.79 m | 0.000000 l/h | .000 | .0001 | 0.00 \X\B0C | Top= 0.17m FCL | CC= 3.12m FFB | 0.00 l/s | 0.00 l/s | 0.0 Pa | 0.00 m/s | Cooling return
01.0001.00 | 00 Ground floor | ML-Copper pipes length 5 m 15x1 mm | 232 | CC= 3.10m SSL | 2.98 m | 0 Pa | NN=2.78 m | 01 | ins= 0.000000 mm | Edge= 3.10m SSL | Y=20.32 | CC= 0.20m FCL | Office | Dra.no: 1 | 189 | 00.23 | 0 | Storey: 2 | Cooling return | X=38.61 | NNUK=2.78 m | 0.000000 l/h | .000 | .0001 | 0.00 \X\B0C | Top= 0.19m FCL | CC= 3.10m FFB | 0.00 l/s | 0.00 l/s | 0.0 Pa | 0.00 m/s | Cooling return
01.0025.00 | 00 Ground floor | ML-Copper pipes length 5 m 15x1 mm-Pipe insulation 9x15 mm gray insulation thickness 9 mm-9 | 2994.58 | CC= 3.10m SSL | 3.10 m | 25583 Pa | NN=2.90 m | 01 | ins= 9.000000 mm | Edge= 3.09m SSL | Y=10.94 | CC= 0.40m FCL | Entrance | Dra.no: 1 | 2 | 00.01 | 3 | Storey: 2 | Coldwater | X=21.92 | NNUK=2.89 m | 1403.999949 l/h | .000 | .0025 | 0.00 \X\B0C | Top= 0.38m FCL | CC= 3.10m FFB | 0.30 l/s | 0.39 l/s | 113847.8 Pa | 2.24 m/s | Coldwater | Pipe insulation | ZP150/915 | PW
01.0025.01 | 00 Ground floor | ML-Copper pipes length 5 m 15x1 mm-Pipe insulation 9x15 mm gray insulation thickness 9 mm-9 | 1245.88 | CC= 3.10m SSL | 3.10 m | 25583 Pa | NN=2.90 m | 01 | ins= 9.000000 mm | Edge= 3.09m SSL | Y=10.96 | CC= 0.40m FCL | Entrance | Dra.no: 1 | 2 | 00.01 | 1 | Storey: 2 | Coldwater | X=18.90 | NNUK=2.89 m | 1403.999949 l/h | .001 | .0025 | 0.00 \X\B0C | Top= 0.38m FCL | CC= 3.10m FFB | 0.30 l/s | 0.39 l/s | 113847.8 Pa | 2.24 m/s | Coldwater | Pipe insulation | ZP150/915 | PW
01.0026.00 | 00 Ground floor | ML-Copper pipes length 5 m 15x1 mm-Pipe insulation 9x15 mm gray insulation thickness 9 mm-9 | 1052.54 | CC= 3.10m SSL | 3.10 m | 3636 Pa | NN=2.90 m | 01 | ins= 9.000000 mm | Edge= 3.09m SSL | Y=12.23 | CC= 0.20m FCL | wc | Dra.no: 1 | 2 | 00.06 | 1 | Storey: 2 | Coldwater | X=18.90 | NNUK=2.89 m | 935.999966 l/h | .000 | .0026 | 0.00 \X\B0C | Top= 0.18m FCL | CC= 3.10m FFB | 0.21 l/s | 0.26 l/s | 88265.0 Pa | 1.55 m/s | Coldwater | Pipe insulation | ZP150/915 | PW
01.0027.00 | 00 Ground floor | ML-Copper pipes length 5 m 15x1 mm-Pipe insulation 9x15 mm gray insulation thickness 9 mm-9 | 1048.08 | CC= 3.10m SSL | 3.10 m | 84629 Pa | NN=2.90 m | 01 | ins= 9.000000 mm | Edge= 3.09m SSL | Y=13.30 | CC= 0.20m FCL | wc | Dra.no: 1 | 2 | 00.08 | 1 | Storey: 2 | Coldwater | X=18.90 | NNUK=2.89 m | 467.999983 l/h | .000 | .0027 | 0.00 \X\B0C | Top= 0.18m FCL | CC= 3.10m FFB | 0.13 l/s | 0.13 l/s | 84629.4 Pa | 0.98 m/s | Coldwater | Pipe insulation | ZP150/915 | PW
01.0027.00 | 00 Ground floor | ML-Copper pipes length 5 m 15x1 mm-Pipe insulation 9x15 mm gray insulation thickness 9 mm-9 | 39.3098 | CC= 0.75m SSL | 0.75 m | 84629 Pa | NN=0.56 m | 01 | ins= 9.000000 mm | Edge= 0.74m SSL | Y=14.43 | CC= 2.74m FCL |  | Dra.no: 1 | 2 |  | 0 | Storey: 2 | Coldwater | X=18.73 | NNUK=0.54 m | 467.999983 l/h | .000 | .0027 | 0.00 \X\B0C | Top= 0.00m FCL | CC= 0.75m FFB | 0.13 l/s | 0.13 l/s | 84629.4 Pa | 0.98 m/s | Coldwater | Pipe insulation | ZP150/915 | PW
01.0027.01 | 00 Ground floor | ML-Copper pipes length 5 m 15x1 mm-Pipe insulation 9x15 mm gray insulation thickness 9 mm-9 | 12 | CC= 3.10m SSL | 3.10 m | 84629 Pa | NN=2.90 m | 01 | ins= 9.000000 mm | Edge= 3.08m SSL | Y=14.37 | CC= 0.20m FCL | wc | Dra.no: 1 | 2 | 00.07 | 0 | Storey: 2 | Coldwater | X=18.88 | NNUK=2.89 m | 467.999983 l/h | .001 | .0027 | 0.00 \X\B0C | Top= 0.18m FCL | CC= 3.10m FFB | 0.13 l/s | 0.13 l/s | 84629.4 Pa | 0.98 m/s | Coldwater | Pipe insulation | ZP150/915 | PW
01.0027.02 | 00 Ground floor | ML-Copper pipes length 5 m 15x1 mm-Pipe insulation 9x15 mm gray insulation thickness 9 mm-9 | 20.8629 | CC= 0.75m SSL | 0.75 m | 84629 Pa | NN=0.56 m | 01 | ins= 9.000000 mm | Edge= 0.74m SSL | Y=14.37 | CC= 2.74m FCL |  | Dra.no: 1 | 2 |  | 0 | Storey: 2 | Coldwater | X=18.74 | NNUK=0.54 m | 467.999983 l/h | .002 | .0027 | 0.00 \X\B0C | Top= 0.00m FCL | CC= 0.75m FFB | 0.13 l/s | 0.13 l/s | 84629.4 Pa | 0.98 m/s | Coldwater | Pipe insulation | ZP150/915 | PW
01.0027.03 | 00 Ground floor | ML-Copper pipes length 5 m 15x1 mm-Pipe insulation 9x15 mm gray insulation thickness 9 mm-9 | 2309 | CC= 0.77m SSL | 0.77 m | 84629 Pa | NN=0.57 m | 01 | ins= 9.000000 mm | Edge= 0.76m SSL | Y=14.37 | CC= 2.53m FCL | wc | Dra.no: 1 | 2 | 00.07 | 2 | Storey: 2 | Coldwater | X=18.78 | NNUK=0.56 m | 467.999983 l/h | .003 | .0027 | 0.00 \X\B0C | Top= 2.51m FCL | CC= 0.77m FFB | 0.13 l/s | 0.13 l/s | 84629.4 Pa | 0.98 m/s | Coldwater | Pipe insulation | ZP150/915 | PW
01.0027.04 | 00 Ground floor | ML-Copper pipes length 5 m 15x1 mm-Pipe insulation 9x15 mm gray insulation thickness 9 mm-9 | 71.5395 | CC= 3.10m SSL | 3.10 m | 84629 Pa | NN=2.90 m | 01 | ins= 9.000000 mm | Edge= 3.08m SSL | Y=14.37 | CC= 0.20m FCL | wc | Dra.no: 1 | 2 | 00.07 | 0 | Storey: 2 | Coldwater | X=18.80 | NNUK=2.89 m | 467.999983 l/h | .004 | .0027 | 0.00 \X\B0C | Top= 0.18m FCL | CC= 3.10m FFB | 0.13 l/s | 0.13 l/s | 84629.4 Pa | 0.98 m/s | Coldwater | Pipe insulation | ZP150/915 | PW
01.0028.00 | 00 Ground floor | ML-Copper pipes length 5 m 15x1 mm-Pipe insulation 9x15 mm gray insulation thickness 9 mm-9 | 56.5435 | CC= 0.75m SSL | 0.75 m | 83283 Pa | NN=0.56 m | 01 | ins= 9.000000 mm | Edge= 0.74m SSL | Y=13.37 | CC= 2.74m FCL |  | Dra.no: 1 | 2 |  | 0 | Storey: 2 | Coldwater | X=18.73 | NNUK=0.54 m | 467.999983 l/h | .000 | .0028 | 0.00 \X\B0C | Top= 0.00m FCL | CC= 0.75m FFB | 0.13 l/s | 0.13 l/s | 83283.5 Pa | 0.98 m/s | Coldwater | Pipe insulation | ZP150/915 | PW
01.0028.02 | 00 Ground floor | ML-Copper pipes length 5 m 15x1 mm-Pipe insulation 9x15 mm gray insulation thickness 9 mm-9 | 20.8629 | CC= 0.75m SSL | 0.75 m | 83283 Pa | NN=0.56 m | 01 | ins= 9.000000 mm | Edge= 0.74m SSL | Y=13.29 | CC= 2.74m FCL |  | Dra.no: 1 | 2 |  | 0 | Storey: 2 | Coldwater | X=18.74 | NNUK=0.54 m | 467.999983 l/h | .002 | .0028 | 0.00 \X\B0C | Top= 0.00m FCL | CC= 0.75m FFB | 0.13 l/s | 0.13 l/s | 83283.5 Pa | 0.98 m/s | Coldwater | Pipe insulation | ZP150/915 | PW
01.0028.03 | 00 Ground floor | ML-Copper pipes length 5 m 15x1 mm-Pipe insulation 9x15 mm gray insulation thickness 9 mm-9 | 2309 | CC= 0.77m SSL | 0.77 m | 83283 Pa | NN=0.57 m | 01 | ins= 9.000000 mm | Edge= 0.76m SSL | Y=13.29 | CC= 2.53m FCL | wc | Dra.no: 1 | 2 | 00.08 | 2 | Storey: 2 | Coldwater | X=18.78 | NNUK=0.56 m | 467.999983 l/h | .003 | .0028 | 0.00 \X\B0C | Top= 2.51m FCL | CC= 0.77m FFB | 0.13 l/s | 0.13 l/s | 83283.5 Pa | 0.98 m/s | Coldwater | Pipe insulation | ZP150/915 | PW
01.0028.04 | 00 Ground floor | ML-Copper pipes length 5 m 15x1 mm-Pipe insulation 9x15 mm gray insulation thickness 9 mm-9 | 89.1596 | CC= 3.10m SSL | 3.10 m | 83283 Pa | NN=2.90 m | 01 | ins= 9.000000 mm | Edge= 3.08m SSL | Y=13.29 | CC= 0.20m FCL | wc | Dra.no: 1 | 2 | 00.08 | 0 | Storey: 2 | Coldwater | X=18.80 | NNUK=2.89 m | 467.999983 l/h | .004 | .0028 | 0.00 \X\B0C | Top= 0.18m FCL | CC= 3.10m FFB | 0.13 l/s | 0.13 l/s | 83283.5 Pa | 0.98 m/s | Coldwater | Pipe insulation | ZP150/915 | PW
01.0029.00 | 00 Ground floor | ML-Copper pipes length 5 m 15x1 mm-Pipe insulation 9x15 mm gray insulation thickness 9 mm-9 | 54.3659 | CC= 0.75m SSL | 0.75 m | 83280 Pa | NN=0.56 m | 01 | ins= 9.000000 mm | Edge= 0.74m SSL | Y=12.29 | CC= 2.74m FCL |  | Dra.no: 1 | 2 |  | 0 | Storey: 2 | Coldwater | X=18.73 | NNUK=0.54 m | 467.999983 l/h | .000 | .0029 | 0.00 \X\B0C | Top= 0.00m FCL | CC= 0.75m FFB | 0.13 l/s | 0.13 l/s | 83280.4 Pa | 0.98 m/s | Coldwater | Pipe insulation | ZP150/915 | PW
01.0029.02 | 00 Ground floor | ML-Copper pipes length 5 m 15x1 mm-Pipe insulation 9x15 mm gray insulation thickness 9 mm-9 | 26.1138 | CC= 0.75m SSL | 0.75 m | 83280 Pa | NN=0.56 m | 01 | ins= 9.000000 mm | Edge= 0.74m SSL | Y=12.21 | CC= 2.74m FCL |  | Dra.no: 1 | 2 |  | 0 | Storey: 2 | Coldwater | X=18.74 | NNUK=0.54 m | 467.999983 l/h | .002 | .0029 | 0.00 \X\B0C | Top= 0.00m FCL | CC= 0.75m FFB | 0.13 l/s | 0.13 l/s | 83280.4 Pa | 0.98 m/s | Coldwater | Pipe insulation | ZP150/915 | PW
01.0029.03 | 00 Ground floor | ML-Copper pipes length 5 m 15x1 mm-Pipe insulation 9x15 mm gray insulation thickness 9 mm-9 | 2309 | CC= 0.77m SSL | 0.77 m | 83280 Pa | NN=0.57 m | 01 | ins= 9.000000 mm | Edge= 0.76m SSL | Y=12.21 | CC= 2.53m FCL | wc | Dra.no: 1 | 2 | 00.06 | 2 | Storey: 2 | Coldwater | X=18.79 | NNUK=0.56 m | 467.999983 l/h | .003 | .0029 | 0.00 \X\B0C | Top= 2.51m FCL | CC= 0.77m FFB | 0.13 l/s | 0.13 l/s | 83280.4 Pa | 0.98 m/s | Coldwater | Pipe insulation | ZP150/915 | PW
01.0029.04 | 00 Ground floor | ML-Copper pipes length 5 m 15x1 mm-Pipe insulation 9x15 mm gray insulation thickness 9 mm-9 | 84.2889 | CC= 3.10m SSL | 3.10 m | 83280 Pa | NN=2.90 m | 01 | ins= 9.000000 mm | Edge= 3.08m SSL | Y=12.21 | CC= 0.20m FCL | wc | Dra.no: 1 | 2 | 00.06 | 0 | Storey: 2 | Coldwater | X=18.81 | NNUK=2.89 m | 467.999983 l/h | .004 | .0029 | 0.00 \X\B0C | Top= 0.18m FCL | CC= 3.10m FFB | 0.13 l/s | 0.13 l/s | 83280.4 Pa | 0.98 m/s | Coldwater | Pipe insulation | ZP150/915 | PW
01.0032.00 | 00 Ground floor | ML-Copper pipes length 5 m 15x1 mm-Pipe insulation 9x15 mm gray insulation thickness 9 mm-9 | 349.926 | CC= 3.10m SSL | 3.10 m | 4058 Pa | NN=2.90 m | 01 | ins= 9.000000 mm | Edge= 3.09m SSL | Y=13.51 | CC= 0.20m FCL | corridor | Dra.no: 1 | 2 | 00.04 | 0 | Storey: 2 | Coldwater | X=21.99 | NNUK=2.89 m | 1223.999986 l/h | .000 | .0032 | 0.00 \X\B0C | Top= 0.18m FCL | CC= 3.10m FFB | 0.27 l/s | 0.34 l/s | 144299.1 Pa | 2.00 m/s | Coldwater | Pipe insulation | ZP150/915 | PW
01.0032.00 | 00 Ground floor | ML-Copper pipes length 5 m 15x1 mm-Pipe insulation 9x15 mm gray insulation thickness 9 mm-9 | 664.118 | CC= 3.10m SSL | 3.10 m | 4058 Pa | NN=2.90 m | 01 | ins= 9.000000 mm | Edge= 3.09m SSL | Y=12.82 | CC= 0.20m FCL | corridor | Dra.no: 1 | 2 | 00.04 | 1 | Storey: 2 | Coldwater | X=21.99 | NNUK=2.89 m | 1223.999986 l/h | .000 | .0032 | 0.00 \X\B0C | Top= 0.18m FCL | CC= 3.10m FFB | 0.27 l/s | 0.34 l/s | 144299.1 Pa | 2.00 m/s | Coldwater | Pipe insulation | ZP150/915 | PW
01.0034.00 | 00 Ground floor | ML-Copper pipes length 5 m 15x1 mm-Pipe insulation 9x15 mm gray insulation thickness 9 mm-9 | 372.499 | CC= 3.10m SSL | 3.10 m | 1297 Pa | NN=2.90 m | 01 | ins= 9.000000 mm | Edge= 3.09m SSL | Y=14.56 | CC= 0.20m FCL | corridor | Dra.no: 1 | 2 | 00.04 | 0 | Storey: 2 | Coldwater | X=21.99 | NNUK=2.89 m | 504.000002 l/h | .000 | .0034 | 0.00 \X\B0C | Top= 0.18m FCL | CC= 3.10m FFB | 0.14 l/s | 0.14 l/s | 138190.5 Pa | 1.05 m/s | Coldwater | Pipe insulation | ZP150/915 | PW
01.0034.00 | 00 Ground floor | ML-Copper pipes length 5 m 15x1 mm-Pipe insulation 9x15 mm gray insulation thickness 9 mm-9 | 645.407 | CC= 3.10m SSL | 3.10 m | 1297 Pa | NN=2.90 m | 01 | ins= 9.000000 mm | Edge= 3.09m SSL | Y=13.89 | CC= 0.20m FCL | corridor | Dra.no: 1 | 2 | 00.04 | 1 | Storey: 2 | Coldwater | X=21.99 | NNUK=2.89 m | 504.000002 l/h | .000 | .0034 | 0.00 \X\B0C | Top= 0.18m FCL | CC= 3.10m FFB | 0.14 l/s | 0.14 l/s | 138190.5 Pa | 1.05 m/s | Coldwater | Pipe insulation | ZP150/915 | PW
01.0034.01 | 00 Ground floor | ML-Copper pipes length 5 m 15x1 mm-Pipe insulation 9x15 mm gray insulation thickness 9 mm-9 | 1280.48 | CC= 3.10m SSL | 3.10 m | 1297 Pa | NN=2.90 m | 01 | ins= 9.000000 mm | Edge= 3.09m SSL | Y=14.95 | CC= 0.20m FCL | corridor | Dra.no: 1 | 2 | 00.04 | 1 | Storey: 2 | Coldwater | X=22.01 | NNUK=2.89 m | 504.000002 l/h | .001 | .0034 | 0.00 \X\B0C | Top= 0.18m FCL | CC= 3.10m FFB | 0.14 l/s | 0.14 l/s | 138190.5 Pa | 1.05 m/s | Coldwater | Pipe insulation | ZP150/915 | PW
01.0034.02 | 00 Ground floor | ML-Copper pipes length 5 m 15x1 mm-Pipe insulation 9x15 mm gray insulation thickness 9 mm-9 | 205.646 | CC= 3.10m SSL | 3.10 m | 1297 Pa | NN=2.90 m | 01 | ins= 9.000000 mm | Edge= 3.09m SSL | Y=14.96 | CC= 0.20m FCL | wc | Dra.no: 1 | 2 | 00.09 | 0 | Storey: 2 | Coldwater | X=23.31 | NNUK=2.89 m | 504.000002 l/h | .002 | .0034 | 0.00 \X\B0C | Top= 0.18m FCL | CC= 3.10m FFB | 0.14 l/s | 0.14 l/s | 138190.5 Pa | 1.05 m/s | Coldwater | Pipe insulation | ZP150/915 | PW
01.0034.03 | 00 Ground floor | ML-Copper pipes length 5 m 15x1 mm-Pipe insulation 9x15 mm gray insulation thickness 9 mm-9 | 2434 | CC= 3.08m SSL | 3.08 m | 1297 Pa | NN=2.88 m | 01 | ins= 9.000000 mm | Edge= 3.07m SSL | Y=15.19 | CC= 0.22m FCL | wc | Dra.no: 1 | 2 | 00.09 | 2 | Storey: 2 | Coldwater | X=23.31 | NNUK=2.87 m | 504.000002 l/h | .003 | .0034 | 0.00 \X\B0C | Top= 0.20m FCL | CC= 3.08m FFB | 0.14 l/s | 0.14 l/s | 138190.5 Pa | 1.05 m/s | Coldwater | Pipe insulation | ZP150/915 | PW
01.0034.04 | 00 Ground floor | ML-Copper pipes length 5 m 15x1 mm-Pipe insulation 9x15 mm gray insulation thickness 9 mm-9 | 5.74596 | CC= 0.63m SSL | 0.63 m | 1297 Pa | NN=0.43 m | 01 | ins= 9.000000 mm | Edge= 0.61m SSL | Y=15.17 | CC= 2.67m FCL | wc | Dra.no: 1 | 2 | 00.09 | 0 | Storey: 2 | Coldwater | X=23.31 | NNUK=0.42 m | 504.000002 l/h | .004 | .0034 | 0.00 \X\B0C | Top= 2.65m FCL | CC= 0.63m FFB | 0.14 l/s | 0.14 l/s | 138190.5 Pa | 1.05 m/s | Coldwater | Pipe insulation | ZP150/915 | PW
01.0037.00 | 00 Ground floor | ML-Copper pipes length 5 m 15x1 mm-Pipe insulation 9x15 mm gray insulation thickness 9 mm-9 | 31.0754 | CC= 0.76m SSL | 0.76 m | 83374 Pa | NN=0.56 m | 01 | ins= 9.000000 mm | Edge= 0.74m SSL | Y=13.92 | CC= 2.74m FCL |  | Dra.no: 1 | 2 |  | 0 | Storey: 2 | Coldwater | X=22.28 | NNUK=0.54 m | 467.999983 l/h | .000 | .0037 | 0.00 \X\B0C | Top= 0.00m FCL | CC= 0.76m FFB | 0.13 l/s | 0.13 l/s | 83373.6 Pa | 0.98 m/s | Coldwater | Pipe insulation | ZP150/915 | PW
01.0037.02 | 00 Ground floor | ML-Copper pipes length 5 m 15x1 mm-Pipe insulation 9x15 mm gray insulation thickness 9 mm-9 | 29.6402 | CC= 0.76m SSL | 0.76 m | 83374 Pa | NN=0.56 m | 01 | ins= 9.000000 mm | Edge= 0.74m SSL | Y=13.87 | CC= 2.74m FCL |  | Dra.no: 1 | 2 |  | 0 | Storey: 2 | Coldwater | X=22.26 | NNUK=0.54 m | 467.999983 l/h | .002 | .0037 | 0.00 \X\B0C | Top= 0.00m FCL | CC= 0.76m FFB | 0.13 l/s | 0.13 l/s | 83373.6 Pa | 0.98 m/s | Coldwater | Pipe insulation | ZP150/915 | PW
01.0037.03 | 00 Ground floor | ML-Copper pipes length 5 m 15x1 mm-Pipe insulation 9x15 mm gray insulation thickness 9 mm-9 | 2309 | CC= 0.77m SSL | 0.77 m | 83374 Pa | NN=0.57 m | 01 | ins= 9.000000 mm | Edge= 0.76m SSL | Y=13.87 | CC= 2.73m FCL |  | Dra.no: 1 | 2 |  | 2 | Storey: 2 | Coldwater | X=22.21 | NNUK=0.56 m | 467.999983 l/h | .003 | .0037 | 0.00 \X\B0C | Top= 0.00m FCL | CC= 0.77m FFB | 0.13 l/s | 0.13 l/s | 83373.6 Pa | 0.98 m/s | Coldwater | Pipe insulation | ZP150/915 | PW
01.0037.04 | 00 Ground floor | ML-Copper pipes length 5 m 15x1 mm-Pipe insulation 9x15 mm gray insulation thickness 9 mm-9 | 190.55 | CC= 3.10m SSL | 3.10 m | 83374 Pa | NN=2.90 m | 01 | ins= 9.000000 mm | Edge= 3.08m SSL | Y=13.87 | CC= 0.40m FCL |  | Dra.no: 1 | 2 |  | 0 | Storey: 2 | Coldwater | X=22.19 | NNUK=2.89 m | 467.999983 l/h | .004 | .0037 | 0.00 \X\B0C | Top= 0.00m FCL | CC= 3.10m FFB | 0.13 l/s | 0.13 l/s | 83373.6 Pa | 0.98 m/s | Coldwater | Pipe insulation | ZP150/915 | PW
01.0039.00 | 00 Ground floor | ML-Copper pipes length 5 m 15x1 mm-Pipe insulation 9x15 mm gray insulation thickness 9 mm-9 | 28.9939 | CC= 0.76m SSL | 0.76 m | 83380 Pa | NN=0.56 m | 01 | ins= 9.000000 mm | Edge= 0.74m SSL | Y=12.81 | CC= 2.74m FCL |  | Dra.no: 1 | 2 |  | 0 | Storey: 2 | Coldwater | X=22.28 | NNUK=0.54 m | 467.999983 l/h | .000 | .0039 | 0.00 \X\B0C | Top= 0.00m FCL | CC= 0.76m FFB | 0.13 l/s | 0.13 l/s | 83380.3 Pa | 0.98 m/s | Coldwater | Pipe insulation | ZP150/915 | PW
01.0039.02 | 00 Ground floor | ML-Copper pipes length 5 m 15x1 mm-Pipe insulation 9x15 mm gray insulation thickness 9 mm-9 | 29.6402 | CC= 0.76m SSL | 0.76 m | 83380 Pa | NN=0.56 m | 01 | ins= 9.000000 mm | Edge= 0.74m SSL | Y=12.76 | CC= 2.74m FCL |  | Dra.no: 1 | 2 |  | 0 | Storey: 2 | Coldwater | X=22.27 | NNUK=0.54 m | 467.999983 l/h | .002 | .0039 | 0.00 \X\B0C | Top= 0.00m FCL | CC= 0.76m FFB | 0.13 l/s | 0.13 l/s | 83380.3 Pa | 0.98 m/s | Coldwater | Pipe insulation | ZP150/915 | PW
01.0039.03 | 00 Ground floor | ML-Copper pipes length 5 m 15x1 mm-Pipe insulation 9x15 mm gray insulation thickness 9 mm-9 | 2309 | CC= 0.77m SSL | 0.77 m | 83380 Pa | NN=0.57 m | 01 | ins= 9.000000 mm | Edge= 0.76m SSL | Y=12.76 | CC= 2.73m FCL |  | Dra.no: 1 | 2 |  | 2 | Storey: 2 | Coldwater | X=22.22 | NNUK=0.56 m | 467.999983 l/h | .003 | .0039 | 0.00 \X\B0C | Top= 0.00m FCL | CC= 0.77m FFB | 0.13 l/s | 0.13 l/s | 83380.3 Pa | 0.98 m/s | Coldwater | Pipe insulation | ZP150/915 | PW
01.0039.04 | 00 Ground floor | ML-Copper pipes length 5 m 15x1 mm-Pipe insulation 9x15 mm gray insulation thickness 9 mm-9 | 201.54 | CC= 3.10m SSL | 3.10 m | 83380 Pa | NN=2.90 m | 01 | ins= 9.000000 mm | Edge= 3.08m SSL | Y=12.76 | CC= 0.40m FCL |  | Dra.no: 1 | 2 |  | 0 | Storey: 2 | Coldwater | X=22.20 | NNUK=2.89 m | 467.999983 l/h | .004 | .0039 | 0.00 \X\B0C | Top= 0.00m FCL | CC= 3.10m FFB | 0.13 l/s | 0.13 l/s | 83380.3 Pa | 0.98 m/s | Coldwater | Pipe insulation | ZP150/915 | PW
01.0041.00 | 00 Ground floor | ML-Copper pipes length 5 m 15x1 mm-Pipe insulation 9x15 mm gray insulation thickness 9 mm-9 | 1045.38 | CC= 3.10m SSL | 3.10 m | 136330 Pa | NN=2.90 m | 01 | ins= 9.000000 mm | Edge= 3.09m SSL | Y=10.95 | CC= 0.40m FCL | Entrance | Dra.no: 1 | 2 | 00.01 | 1 | Storey: 2 | Coldwater | X=23.11 | NNUK=2.89 m | 252.000001 l/h | .000 | .0041 | 0.00 \X\B0C | Top= 0.38m FCL | CC= 3.10m FFB | 0.07 l/s | 0.07 l/s | 136329.5 Pa | 0.53 m/s | Coldwater | Pipe insulation | ZP150/915 | PW
01.0041.02 | 00 Ground floor | ML-Copper pipes length 5 m 15x1 mm-Pipe insulation 9x15 mm gray insulation thickness 9 mm-9 | 2434 | CC= 3.08m SSL | 3.08 m | 136330 Pa | NN=2.88 m | 01 | ins= 9.000000 mm | Edge= 3.07m SSL | Y=12.01 | CC= 0.22m FCL | wc | Dra.no: 1 | 2 | 00.10 | 2 | Storey: 2 | Coldwater | X=23.11 | NNUK=2.87 m | 252.000001 l/h | .002 | .0041 | 0.00 \X\B0C | Top= 0.20m FCL | CC= 3.08m FFB | 0.07 l/s | 0.07 l/s | 136329.5 Pa | 0.53 m/s | Coldwater | Pipe insulation | ZP150/915 | PW
01.0041.03 | 00 Ground floor | ML-Copper pipes length 5 m 15x1 mm-Pipe insulation 9x15 mm gray insulation thickness 9 mm-9 | 2.69473 | CC= 0.63m SSL | 0.63 m | 136330 Pa | NN=0.43 m | 01 | ins= 9.000000 mm | Edge= 0.61m SSL | Y=12.03 | CC= 2.67m FCL | wc | Dra.no: 1 | 2 | 00.10 | 0 | Storey: 2 | Coldwater | X=23.11 | NNUK=0.42 m | 252.000001 l/h | .003 | .0041 | 0.00 \X\B0C | Top= 2.65m FCL | CC= 0.63m FFB | 0.07 l/s | 0.07 l/s | 136329.5 Pa | 0.53 m/s | Coldwater | Pipe insulation | ZP150/915 | PW
02.0001.00 | 00 Ground floor | ML-Copper pipes length 5 m 15x1 mm-Pipe insulation 9x15 mm gray insulation thickness 9 mm-9 | 130 | CC= 3.02m SSL | 2.90 m | 0 Pa | NN=2.70 m | 02 | ins= 9.000000 mm | Edge= 3.00m SSL | Y=20.34 | CC= 0.28m FCL | Office | Dra.no: 1 | 188 | 00.23 | 0 | Storey: 2 | Cooling Flow | X=35.55 | NNUK=2.69 m | 0.000000 l/h | .000 | .0001 | 0.00 \X\B0C | Top= 0.26m FCL | CC= 3.02m FFB | 0.00 l/s | 0.00 l/s | 0.0 Pa | 0.00 m/s | Cooling flow | Pipe insulation | ZP150/915 | Cooling
02.0001.00 | 00 Ground floor | ML-Copper pipes length 5 m 15x1 mm-Pipe insulation 9x15 mm gray insulation thickness 9 mm-9 | 132 | CC= 2.87m SSL | 2.75 m | 0 Pa | NN=2.55 m | 02 | ins= 9.000000 mm | Edge= 2.86m SSL | Y=20.32 | CC= 0.43m FCL | Office | Dra.no: 1 | 188 | 00.23 | 0 | Storey: 2 | Cooling Flow | X=35.55 | NNUK=2.54 m | 0.000000 l/h | .000 | .0001 | 0.00 \X\B0C | Top= 0.41m FCL | CC= 2.87m FFB | 0.00 l/s | 0.00 l/s | 0.0 Pa | 0.00 m/s | Cooling flow | Pipe insulation | ZP150/915 | Cooling
02.0002.00 | 00 Ground floor | ML-Copper pipes length 5 m 15x1 mm | 132 | CC= 3.00m SSL | 2.88 m | 0 Pa | NN=2.68 m | 02 | ins= 0.000000 mm | Edge= 3.00m SSL | Y=20.32 | CC= 0.30m FCL | Office | Dra.no: 1 | 188 | 00.23 | 0 | Storey: 2 | Cooling Flow | X=38.67 | NNUK=2.68 m | 0.000000 l/h | .000 | .0002 | 0.00 \X\B0C | Top= 0.29m FCL | CC= 3.00m FFB | 0.00 l/s | 0.00 l/s | 0.0 Pa | 0.00 m/s | Cooling flow |  |  | Cooling
02.0002.00 | 00 Ground floor | ML-Copper pipes length 5 m 15x1 mm-Pipe insulation 9x15 mm gray insulation thickness 9 mm-9 | 7 | CC= 3.07m SSL | 3.20 m | 37075 Pa | NN=3.00 m | 02 | ins= 9.000000 mm | Edge= 3.06m SSL | Y=11.09 | CC= 0.23m FCL | Shaft | Dra.no: 1 | 3 | 00.27 | 0 | Storey: 2 | Hotwater | X=29.36 | NNUK=2.99 m | 1260.000005 l/h | .000 | .0002 | 63.38 \X\B0C | Top= 0.22m FCL | CC= 3.07m FFB | 0.27 l/s | 0.35 l/s | 185479.5 Pa | 2.05 m/s | Hotwater | Pipe insulation | ZP150/915
02.0002.00 | 00 Ground floor | ML-Copper pipes length 5 m 15x1 mm | 3067.68 | CC= 3.02m SSL | 2.90 m | 0 Pa | NN=2.70 m | 02 | ins= 0.000000 mm | Edge= 3.01m SSL | Y=20.48 | CC= 0.28m FCL | Office | Dra.no: 1 | 188 | 00.23 | 3 | Storey: 2 | Cooling Flow | X=35.59 | NNUK=2.69 m | 0.000000 l/h | .000 | .0002 | 0.00 \X\B0C | Top= 0.27m FCL | CC= 3.02m FFB | 0.00 l/s | 0.00 l/s | 0.0 Pa | 0.00 m/s | Cooling flow |  |  | Cooling
02.0002.00 | 00 Ground floor | ML-Copper pipes length 5 m 15x1 mm | 121.87 | CC= 3.02m SSL | 2.90 m | 0 Pa | NN=2.70 m | 02 | ins= 0.000000 mm | Edge= 3.01m SSL | Y=20.46 | CC= 0.28m FCL | Office | Dra.no: 1 | 188 | 00.23 | 0 | Storey: 2 | Cooling Flow | X=38.67 | NNUK=2.69 m | 0.000000 l/h | .000 | .0002 | 0.00 \X\B0C | Top= 0.27m FCL | CC= 3.02m FFB | 0.00 l/s | 0.00 l/s | 0.0 Pa | 0.00 m/s | Cooling flow |  |  | Cooling
02.0002.02 | 00 Ground floor | ML-Copper pipes length 5 m 15x1 mm-Pipe insulation 9x15 mm gray insulation thickness 9 mm-9 | 6028.57 | CC= 3.05m SSL | 3.18 m | 37075 Pa | NN=2.98 m | 02 | ins= 9.000000 mm | Edge= 3.03m SSL | Y=11.09 | CC= 0.26m FCL | Shaft | Dra.no: 1 | 3 | 00.27 | 6 | Storey: 2 | Hotwater | X=29.35 | NNUK=2.96 m | 1260.000005 l/h | .002 | .0002 | 63.38 \X\B0C | Top= 0.24m FCL | CC= 3.05m FFB | 0.27 l/s | 0.35 l/s | 185479.5 Pa | 2.05 m/s | Hotwater | Pipe insulation | ZP150/915
02.0003.00 | 00 Ground floor | ML-Copper pipes length 5 m 15x1 mm-Pipe insulation 9x15 mm gray insulation thickness 9 mm-9 | 1362.3 | CC= 3.18m SSL | 3.18 m | 9386 Pa | NN=2.98 m | 02 | ins= 9.000000 mm | Edge= 3.16m SSL | Y=11.09 | CC= 0.32m FCL | Entrance | Dra.no: 1 | 3 | 00.01 | 1 | Storey: 2 | Hotwater | X=23.29 | NNUK=2.96 m | 1008.000004 l/h | .000 | .0003 | 63.21 \X\B0C | Top= 0.31m FCL | CC= 3.18m FFB | 0.22 l/s | 0.28 l/s | 148404.7 Pa | 1.67 m/s | Hotwater | Pipe insulation | ZP150/915
02.0003.00 | 00 Ground floor | ML-Copper pipes length 5 m 15x1 mm-Pipe insulation 9x15 mm gray insulation thickness 9 mm-9 | 223.705 | CC= 3.18m SSL | 3.18 m | 9386 Pa | NN=2.98 m | 02 | ins= 9.000000 mm | Edge= 3.16m SSL | Y=14.76 | CC= 0.12m FCL | corridor | Dra.no: 1 | 3 | 00.04 | 0 | Storey: 2 | Hotwater | X=21.91 | NNUK=2.96 m | 1008.000004 l/h | .000 | .0003 | 63.21 \X\B0C | Top= 0.11m FCL | CC= 3.18m FFB | 0.22 l/s | 0.28 l/s | 148404.7 Pa | 1.67 m/s | Hotwater | Pipe insulation | ZP150/915
02.0003.00 | 00 Ground floor | ML-Copper pipes length 5 m 15x1 mm-Pipe insulation 9x15 mm gray insulation thickness 9 mm-9 | 1019.33 | CC= 3.18m SSL | 3.18 m | 9386 Pa | NN=2.98 m | 02 | ins= 9.000000 mm | Edge= 3.16m SSL | Y=13.71 | CC= 0.12m FCL | corridor | Dra.no: 1 | 3 | 00.04 | 1 | Storey: 2 | Hotwater | X=21.91 | NNUK=2.96 m | 1008.000004 l/h | .000 | .0003 | 63.21 \X\B0C | Top= 0.11m FCL | CC= 3.18m FFB | 0.22 l/s | 0.28 l/s | 148404.7 Pa | 1.67 m/s | Hotwater | Pipe insulation | ZP150/915
02.0003.00 | 00 Ground floor | ML-Copper pipes length 5 m 15x1 mm-Pipe insulation 9x15 mm gray insulation thickness 9 mm-9 | 1019.33 | CC= 3.18m SSL | 3.18 m | 9386 Pa | NN=2.98 m | 02 | ins= 9.000000 mm | Edge= 3.16m SSL | Y=12.67 | CC= 0.12m FCL | corridor | Dra.no: 1 | 3 | 00.04 | 1 | Storey: 2 | Hotwater | X=21.91 | NNUK=2.96 m | 1008.000004 l/h | .000 | .0003 | 63.21 \X\B0C | Top= 0.11m FCL | CC= 3.18m FFB | 0.22 l/s | 0.28 l/s | 148404.7 Pa | 1.67 m/s | Hotwater | Pipe insulation | ZP150/915
02.0003.01 | 00 Ground floor | ML-Copper pipes length 5 m 15x1 mm-Pipe insulation 9x15 mm gray insulation thickness 9 mm-9 | 1536.58 | CC= 3.18m SSL | 3.18 m | 9386 Pa | NN=2.98 m | 02 | ins= 9.000000 mm | Edge= 3.16m SSL | Y=11.11 | CC= 0.32m FCL | Entrance | Dra.no: 1 | 3 | 00.01 | 2 | Storey: 2 | Hotwater | X=21.91 | NNUK=2.96 m | 1008.000004 l/h | .001 | .0003 | 63.21 \X\B0C | Top= 0.31m FCL | CC= 3.18m FFB | 0.22 l/s | 0.28 l/s | 148404.7 Pa | 1.67 m/s | Hotwater | Pipe insulation | ZP150/915
02.0003.01 | 00 Ground floor | ML-Copper pipes length 5 m 15x1 mm-Pipe insulation 9x15 mm gray insulation thickness 9 mm-9 | 1156.83 | CC= 3.18m SSL | 3.18 m | 9386 Pa | NN=2.98 m | 02 | ins= 9.000000 mm | Edge= 3.16m SSL | Y=15.00 | CC= 0.12m FCL | corridor | Dra.no: 1 | 3 | 00.04 | 1 | Storey: 2 | Hotwater | X=21.93 | NNUK=2.96 m | 1008.000004 l/h | .001 | .0003 | 63.21 \X\B0C | Top= 0.11m FCL | CC= 3.18m FFB | 0.22 l/s | 0.28 l/s | 148404.7 Pa | 1.67 m/s | Hotwater | Pipe insulation | ZP150/915
02.0003.02 | 00 Ground floor | ML-Copper pipes length 5 m 15x1 mm-Pipe insulation 9x15 mm gray insulation thickness 9 mm-9 | 41 | CC= 3.18m SSL | 3.18 m | 9386 Pa | NN=2.98 m | 02 | ins= 9.000000 mm | Edge= 3.16m SSL | Y=15.02 | CC= 0.12m FCL | wc | Dra.no: 1 | 3 | 00.09 | 0 | Storey: 2 | Hotwater | X=23.11 | NNUK=2.96 m | 1008.000004 l/h | .002 | .0003 | 63.21 \X\B0C | Top= 0.11m FCL | CC= 3.18m FFB | 0.22 l/s | 0.28 l/s | 148404.7 Pa | 1.67 m/s | Hotwater | Pipe insulation | ZP150/915
02.0006.01 | 00 Ground floor | ML-Copper pipes length 5 m 15x1 mm | 3067.68 | CC= 3.22m SSL | 3.10 m | 0 Pa | NN=2.90 m | 02 | ins= 0.000000 mm | Edge= 3.21m SSL | Y=16.85 | CC= 0.08m FCL | Office | Dra.no: 1 | 188 | 00.23 | 3 | Storey: 2 | Cooling Flow | X=35.59 | NNUK=2.89 m | 0.000000 l/h | .001 | .0006 | 0.00 \X\B0C | Top= 0.07m FCL | CC= 3.22m FFB | 0.00 l/s | 0.00 l/s | 0.0 Pa | 0.00 m/s | Cooling flow |  |  | Cooling
02.0006.02 | 00 Ground floor | ML-Copper pipes length 5 m 15x1 mm | 245 | CC= 3.22m SSL | 3.10 m | 0 Pa | NN=2.90 m | 02 | ins= 0.000000 mm | Edge= 3.21m SSL | Y=16.83 | CC= 0.08m FCL | Office | Dra.no: 1 | 188 | 00.23 | 0 | Storey: 2 | Cooling Flow | X=38.67 | NNUK=2.89 m | 0.000000 l/h | .002 | .0006 | 0.00 \X\B0C | Top= 0.07m FCL | CC= 3.22m FFB | 0.00 l/s | 0.00 l/s | 0.0 Pa | 0.00 m/s | Cooling flow |  |  | Cooling
02.0006.03 | 00 Ground floor | ML-Copper pipes length 5 m 15x1 mm | 331.994 | CC= 3.20m SSL | 3.08 m | 0 Pa | NN=2.88 m | 02 | ins= 0.000000 mm | Edge= 3.20m SSL | Y=16.57 | CC= 0.10m FCL | Office | Dra.no: 1 | 188 | 00.23 | 0 | Storey: 2 | Cooling Flow | X=38.67 | NNUK=2.88 m | 0.000000 l/h | .003 | .0006 | 0.00 \X\B0C | Top= 0.09m FCL | CC= 3.20m FFB | 0.00 l/s | 0.00 l/s | 0.0 Pa | 0.00 m/s | Cooling flow |  |  | Cooling
02.0007.00 | 00 Ground floor | ML-Copper pipes length 5 m 15x1 mm-Pipe insulation 9x15 mm gray insulation thickness 9 mm-9 | 87.9382 | CC= 3.18m SSL | 3.18 m | 134869 Pa | NN=2.98 m | 02 | ins= 9.000000 mm | Edge= 3.16m SSL | Y=15.08 | CC= 0.12m FCL | wc | Dra.no: 1 | 3 | 00.09 | 0 | Storey: 2 | Hotwater | X=23.11 | NNUK=2.96 m | 252.000001 l/h | .000 | .0007 | 0.00 \X\B0C | Top= 0.11m FCL | CC= 3.18m FFB | 0.07 l/s | 0.07 l/s | 134869.3 Pa | 0.53 m/s | Hotwater | Pipe insulation | ZP150/915
02.0007.00 | 00 Ground floor | ML-Copper pipes length 5 m 15x1 mm-Pipe insulation 9x15 mm gray insulation thickness 9 mm-9 | 331.994 | CC= 2.87m SSL | 2.75 m | 0 Pa | NN=2.55 m | 02 | ins= 9.000000 mm | Edge= 2.86m SSL | Y=16.57 | CC= 0.43m FCL | Office | Dra.no: 1 | 188 | 00.23 | 0 | Storey: 2 | Cooling Flow | X=35.55 | NNUK=2.54 m | 0.000000 l/h | .000 | .0007 | 0.00 \X\B0C | Top= 0.41m FCL | CC= 2.87m FFB | 0.00 l/s | 0.00 l/s | 0.0 Pa | 0.00 m/s | Cooling flow | Pipe insulation | ZP150/915 | Cooling
02.0007.01 | 00 Ground floor | ML-Copper pipes length 5 m 15x1 mm-Pipe insulation 9x15 mm gray insulation thickness 9 mm-9 | 2509 | CC= 3.16m SSL | 3.16 m | 134869 Pa | NN=2.96 m | 02 | ins= 9.000000 mm | Edge= 3.14m SSL | Y=15.19 | CC= 0.14m FCL | wc | Dra.no: 1 | 3 | 00.09 | 3 | Storey: 2 | Hotwater | X=23.11 | NNUK=2.94 m | 252.000001 l/h | .001 | .0007 | 0.00 \X\B0C | Top= 0.13m FCL | CC= 3.16m FFB | 0.07 l/s | 0.07 l/s | 134869.3 Pa | 0.53 m/s | Hotwater | Pipe insulation | ZP150/915
02.0007.02 | 00 Ground floor | ML-Copper pipes length 5 m 15x1 mm-Pipe insulation 9x15 mm gray insulation thickness 9 mm-9 | 4.33757 | CC= 0.63m SSL | 0.63 m | 134869 Pa | NN=0.43 m | 02 | ins= 9.000000 mm | Edge= 0.61m SSL | Y=15.17 | CC= 2.67m FCL | wc | Dra.no: 1 | 3 | 00.09 | 0 | Storey: 2 | Hotwater | X=23.11 | NNUK=0.42 m | 252.000001 l/h | .002 | .0007 | 0.00 \X\B0C | Top= 2.65m FCL | CC= 0.63m FFB | 0.07 l/s | 0.07 l/s | 134869.3 Pa | 0.53 m/s | Hotwater | Pipe insulation | ZP150/915
02.0007.02 | 00 Ground floor | ML-Copper pipes length 5 m 15x1 mm-Pipe insulation 9x15 mm gray insulation thickness 9 mm-9 | 252.917 | CC= 3.22m SSL | 3.10 m | 0 Pa | NN=2.90 m | 02 | ins= 9.000000 mm | Edge= 3.20m SSL | Y=16.59 | CC= 0.08m FCL | Office | Dra.no: 1 | 188 | 00.23 | 0 | Storey: 2 | Cooling Flow | X=35.55 | NNUK=2.88 m | 0.000000 l/h | .002 | .0007 | 0.00 \X\B0C | Top= 0.07m FCL | CC= 3.22m FFB | 0.00 l/s | 0.00 l/s | 0.0 Pa | 0.00 m/s | Cooling flow | Pipe insulation | ZP150/915 | Cooling
02.0011.00 | 00 Ground floor | ML-Copper pipes length 5 m 15x1 mm-Pipe insulation 9x15 mm gray insulation thickness 9 mm-9 | 888.115 | CC= 3.18m SSL | 3.18 m | 135270 Pa | NN=2.98 m | 02 | ins= 9.000000 mm | Edge= 3.16m SSL | Y=11.10 | CC= 0.32m FCL | Entrance | Dra.no: 1 | 3 | 00.01 | 1 | Storey: 2 | Hotwater | X=23.31 | NNUK=2.96 m | 252.000001 l/h | .000 | .0011 | 0.00 \X\B0C | Top= 0.31m FCL | CC= 3.18m FFB | 0.07 l/s | 0.07 l/s | 135269.8 Pa | 0.53 m/s | Hotwater | Pipe insulation | ZP150/915
02.0011.02 | 00 Ground floor | ML-Copper pipes length 5 m 15x1 mm-Pipe insulation 9x15 mm gray insulation thickness 9 mm-9 | 2509 | CC= 3.16m SSL | 3.16 m | 135270 Pa | NN=2.96 m | 02 | ins= 9.000000 mm | Edge= 3.14m SSL | Y=12.01 | CC= 0.14m FCL | wc | Dra.no: 1 | 3 | 00.10 | 3 | Storey: 2 | Hotwater | X=23.31 | NNUK=2.94 m | 252.000001 l/h | .002 | .0011 | 0.00 \X\B0C | Top= 0.13m FCL | CC= 3.16m FFB | 0.07 l/s | 0.07 l/s | 135269.8 Pa | 0.53 m/s | Hotwater | Pipe insulation | ZP150/915
02.0011.03 | 00 Ground floor | ML-Copper pipes length 5 m 15x1 mm-Pipe insulation 9x15 mm gray insulation thickness 9 mm-9 | 8.79977 | CC= 0.63m SSL | 0.63 m | 135270 Pa | NN=0.43 m | 02 | ins= 9.000000 mm | Edge= 0.61m SSL | Y=12.03 | CC= 2.67m FCL | wc | Dra.no: 1 | 3 | 00.10 | 0 | Storey: 2 | Hotwater | X=23.31 | NNUK=0.42 m | 252.000001 l/h | .003 | .0011 | 0.00 \X\B0C | Top= 2.65m FCL | CC= 0.63m FFB | 0.07 l/s | 0.07 l/s | 135269.8 Pa | 0.53 m/s | Hotwater | Pipe insulation | ZP150/915
03.0000.00 | 00 Ground floor | ML-Copper pipes length 5 m 15x1 mm-Pipe insulation 9x15 mm gray insulation thickness 9 mm-9 | 70.0306 | CC= 3.12m SSL | 3.00 m | 0 Pa | NN=2.80 m | 03 | ins= 9.000000 mm | Edge= 3.11m SSL | Y=20.34 | CC= 0.18m FCL | Office | Dra.no: 1 | 189 | 00.23 | 0 | Storey: 2 | Cooling return | X=35.49 | NNUK=2.79 m | 0.000000 l/h | .000 | .0000 | 0.00 \X\B0C | Top= 0.16m FCL | CC= 3.12m FFB | 0.00 l/s | 0.00 l/s | 0.0 Pa | 0.00 m/s | Cooling return | Pipe insulation | ZP150/915 | Cooling
03.0000.03 | 00 Ground floor | ML-Copper pipes length 5 m 15x1 mm-Pipe insulation 9x15 mm gray insulation thickness 9 mm-9 | 232 | CC= 2.87m SSL | 2.75 m | 0 Pa | NN=2.55 m | 03 | ins= 9.000000 mm | Edge= 2.86m SSL | Y=20.32 | CC= 0.43m FCL | Office | Dra.no: 1 | 189 | 00.23 | 0 | Storey: 2 | Cooling return | X=35.49 | NNUK=2.54 m | 0.000000 l/h | .003 | .0000 | 0.00 \X\B0C | Top= 0.41m FCL | CC= 2.87m FFB | 0.00 l/s | 0.00 l/s | 0.0 Pa | 0.00 m/s | Cooling return | Pipe insulation | ZP150/915 | Cooling
03.0002.00 | 00 Ground floor | ML-Copper pipes length 5 m 15x1 mm-Pipe insulation 9x15 mm gray insulation thickness 9 mm-9 | 32 | CC= 3.07m SSL | 3.20 m | 2413 Pa | NN=3.00 m | 03 | ins= 9.000000 mm | Edge= 3.06m SSL | Y=11.33 | CC= 0.23m FCL | Shaft | Dra.no: 1 | 4 | 00.27 | 0 | Storey: 2 | Circulation | X=29.36 | NNUK=2.99 m | 151.334382 l/h | .000 | .0002 | 61.39 \X\B0C | Top= 0.22m FCL | CC= 3.07m FFB | 0.00 l/s | 0.04 l/s | 2413.1 Pa | 0.32 m/s | Circulation | Pipe insulation | ZP150/915
03.0002.02 | 00 Ground floor | ML-Copper pipes length 5 m 15x1 mm-Pipe insulation 9x15 mm gray insulation thickness 9 mm-9 | 7519.86 | CC= 3.12m SSL | 3.25 m | 2413 Pa | NN=3.05 m | 03 | ins= 9.000000 mm | Edge= 3.11m SSL | Y=11.33 | CC= 0.18m FCL | Shaft | Dra.no: 1 | 4 | 00.27 | 8 | Storey: 2 | Circulation | X=29.35 | NNUK=3.04 m | 151.334382 l/h | .002 | .0002 | 61.39 \X\B0C | Top= 0.17m FCL | CC= 3.12m FFB | 0.00 l/s | 0.04 l/s | 2413.1 Pa | 0.32 m/s | Circulation | Pipe insulation | ZP150/915
03.0002.03 | 00 Ground floor | ML-Copper pipes length 5 m 15x1 mm-Pipe insulation 9x15 mm gray insulation thickness 9 mm-9 | 3706.79 | CC= 3.25m SSL | 3.25 m | 2413 Pa | NN=3.05 m | 03 | ins= 9.000000 mm | Edge= 3.24m SSL | Y=11.34 | CC= 0.25m FCL | Entrance | Dra.no: 1 | 4 | 00.01 | 4 | Storey: 2 | Circulation | X=21.81 | NNUK=3.04 m | 151.334382 l/h | .003 | .0002 | 61.39 \X\B0C | Top= 0.23m FCL | CC= 3.25m FFB | 0.00 l/s | 0.04 l/s | 2413.1 Pa | 0.32 m/s | Circulation | Pipe insulation | ZP150/915
