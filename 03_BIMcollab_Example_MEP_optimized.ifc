Properties of the parts of a building model (IFC2X3), part 6 of 14

# IfcFlowFitting: TP-121203-034 (8)
Type - Pset_ManufacturerTypeInformation - ArticleNumber: TP-121203-034; ModelReference: HT tee 45\X\B0 100x50; Manufacturer: DDS
Type - Pset_PipeFittingTypeCommon - SubType: Junction Tee; NominalDiameter: 100, 100, 50; InnerDiameter: 104.6, 104.6, 46.4; OuterDiameter: 110, 110, 50
Material: IFC Building Material
Pset_DDS - Product Number: TP-121203-034; Medium: Sewer; Manufacturer: DDS; Pipe thickness:: x2.7; Dimension DN: 100 mm; Ins thickness: ins= 0.000000 mm; Product: HT tee 45\X\B0 100x50; Outside dimension: 109.999999; Layer number: 178; Main string number: 00; Dimension tee: 50; Dimension out: 100; Dimension in: 100; Width: 100; Project name: OpenBIM; Height: 0; Insulation k-value: 0; Pressure drop: 0; Insulation WSVO: 0; Flow (m\X\B3/h): 0.0 m\X\B3/h; Angle out: 45; Flow (l/h): 0.000000 l/h; Part number: .000; Sub string number: .0000; Building Part: Building: 0; Flow (l/s): 0.00 l/s; Abs. pressure: 0.0 Pa; Velocity: 0.00 m/s
AC_Pset_RenovationAndPhasing - Renovation Status: Existing
Name | In | Mtg. Above Slab ref Center | Mounting Height | Mtg. Below Ceiling ref Center | Rotation | X | Above Sea Level ref. Bottom | Above Sea Level ref. Center | Model Number | Mtg. Above Slab ref Bottom | Floor number | Length | Mtg. above Finished Floor ref Center | Y | Mtg. Below Ceiling ref Top
Tee | 00 Ground floor | CC= -0.10m SSL | -0.10 m | CC= 3.60m FCL | 270.000000 | X=22.25 | NNUK=-0.40 m | NN=-0.30 m | Dra.no: 1 | Edge= -0.15m SSL | Storey: 2 | 50.0 m | CC= -0.10m FFB | Y=13.49 | Top= 0.00m FCL
Tee | 00 Ground floor | CC= -0.11m SSL | -0.11 m | CC= 3.61m FCL | 270.000000 | X=22.25 | NNUK=-0.41 m | NN=-0.31 m | Dra.no: 1 | Edge= -0.16m SSL | Storey: 2 | 50.0 m | CC= -0.11m FFB | Y=12.45 | Top= 0.00m FCL
Tee | 00 Ground floor | CC= -0.14m SSL | -0.14 m | CC= 3.64m FCL | 359.164654 | X=23.32 | NNUK=-0.44 m | NN=-0.34 m | Dra.no: 1 | Edge= -0.19m SSL | Storey: 2 | 0.1 m | CC= -0.14m FFB | Y=11.21 | Top= 3.59m FCL | Pset_DDS - Room tekst: Entrance; Room number: 00.01
Tee | 00 Ground floor | CC= -0.09m SSL | -0.09 m | CC= 3.59m FCL | 270.000000 | X=22.25 | NNUK=-0.39 m | NN=-0.29 m | Dra.no: 1 | Edge= -0.14m SSL | Storey: 2 | 50.0 m | CC= -0.09m FFB | Y=14.50 | Top= 0.00m FCL
Tee | 01 First floor | CC= -0.27m SSL | -0.14 m | CC= 3.57m FCL | 359.164654 | X=23.32 | NNUK=3.06 m | NN=3.16 m | Dra.no: 2 | Edge= -0.32m SSL | Storey: 3 | 0.1 m | CC= -0.27m FFB | Y=11.21 | Top= 3.52m FCL | Pset_DDS - Room tekst: Restaurant; Room number: 01.03
Tee | 01 First floor | CC= -0.11m SSL | -0.11 m | CC= 3.41m FCL | 270.000000 | X=22.25 | NNUK=3.09 m | NN=3.19 m | Dra.no: 2 | Edge= -0.16m SSL | Storey: 3 | 0.1 m | CC= -0.11m FFB | Y=12.45 | Top= 0.00m FCL
Tee | 01 First floor | CC= -0.10m SSL | -0.10 m | CC= 3.40m FCL | 270.000000 | X=22.25 | NNUK=3.10 m | NN=3.20 m | Dra.no: 2 | Edge= -0.15m SSL | Storey: 3 | 50.0 m | CC= -0.10m FFB | Y=13.49 | Top= 0.00m FCL
Tee | 01 First floor | CC= -0.09m SSL | -0.09 m | CC= 3.39m FCL | 270.000000 | X=22.25 | NNUK=3.11 m | NN=3.21 m | Dra.no: 2 | Edge= -0.14m SSL | Storey: 3 | 50.0 m | CC= -0.09m FFB | Y=14.50 | Top= 0.00m FCL

# IfcFlowFitting: TP-121203-040 (8)
Type - Description: HT tee 45\X\B0 100x100; ApplicableOccurrence: Generic; PredefinedType: JUNCTION
Type - Pset_ManufacturerTypeInformation - ArticleNumber: TP-121203-040; ModelReference: HT tee 45\X\B0 100x100; Manufacturer: DDS
Type - Pset_PipeFittingTypeCommon - SubType: Junction Tee; NominalDiameter: 100, 100, 100; InnerDiameter: 104.6, 104.6, 104.6; OuterDiameter: 110, 110, 110
Material: IFC Building Material
Pset_DDS - Medium: Sewer; Manufacturer: DDS; Rotation: 270.000000; Pipe thickness:: x2.7; Dimension DN: 100 mm; Ins thickness: ins= 0.000000 mm; Product Number: TP-121203-040; Product: HT tee 45\X\B0 100x100; Outside dimension: 109.999999; Layer number: 178; Main string number: 00; Dimension out: 100; Dimension in: 100; Dimension tee: 100; Width: 100; Project name: OpenBIM; Height: 0; Insulation k-value: 0; Pressure drop: 0; Insulation WSVO: 0; Flow (m\X\B3/h): 0.0 m\X\B3/h; Angle out: 45; Flow (l/h): 0.000000 l/h; Part number: .000; Sub string number: .0000; Building Part: Building: 0; Mtg. Below Ceiling ref Top: Top= 0.00m FCL; Flow (l/s): 0.00 l/s; Abs. pressure: 0.0 Pa; Velocity: 0.00 m/s
AC_Pset_RenovationAndPhasing - Renovation Status: Existing
Name | In | Mtg. above Finished Floor ref Center | Mtg. Above Slab ref Center | Above Sea Level ref. Center | Mtg. Below Ceiling ref Center | Length | Model Number | Mtg. Above Slab ref Bottom | Floor number | Mounting Height | Y | X | Above Sea Level ref. Bottom
Tee | 00 Ground floor | CC= -0.07m FFB | CC= -0.07m SSL | NN=-0.27 m | CC= 3.57m FCL | 100.0 m | Dra.no: 1 | Edge= -0.12m SSL | Storey: 2 | -0.07 m | Y=13.46 | X=18.69 | NNUK=-0.37 m
Tee | 00 Ground floor | CC= -0.11m FFB | CC= -0.11m SSL | NN=-0.31 m | CC= 3.61m FCL | 0.2 m | Dra.no: 1 | Edge= -0.16m SSL | Storey: 2 | -0.11 m | Y=12.90 | X=22.25 | NNUK=-0.41 m
Tee | 00 Ground floor | CC= -0.08m FFB | CC= -0.08m SSL | NN=-0.28 m | CC= 3.58m FCL | 100.0 m | Dra.no: 1 | Edge= -0.13m SSL | Storey: 2 | -0.08 m | Y=12.37 | X=18.69 | NNUK=-0.38 m
Tee | 00 Ground floor | CC= -0.10m FFB | CC= -0.10m SSL | NN=-0.30 m | CC= 3.60m FCL | 100.0 m | Dra.no: 1 | Edge= -0.15m SSL | Storey: 2 | -0.10 m | Y=14.02 | X=22.25 | NNUK=-0.40 m
Tee | 01 First floor | CC= -0.07m FFB | CC= -0.07m SSL | NN=3.23 m | CC= 3.37m FCL | 100.0 m | Dra.no: 2 | Edge= -0.12m SSL | Storey: 3 | -0.07 m | Y=13.46 | X=18.69 | NNUK=3.13 m
Tee | 01 First floor | CC= -0.08m FFB | CC= -0.08m SSL | NN=3.22 m | CC= 3.38m FCL | 100.0 m | Dra.no: 2 | Edge= -0.13m SSL | Storey: 3 | -0.08 m | Y=12.37 | X=18.69 | NNUK=3.12 m
Tee | 01 First floor | CC= -0.11m FFB | CC= -0.11m SSL | NN=3.19 m | CC= 3.41m FCL | 0.2 m | Dra.no: 2 | Edge= -0.16m SSL | Storey: 3 | -0.11 m | Y=12.90 | X=22.25 | NNUK=3.09 m
Tee | 01 First floor | CC= -0.10m FFB | CC= -0.10m SSL | NN=3.20 m | CC= 3.40m FCL | 100.0 m | Dra.no: 2 | Edge= -0.15m SSL | Storey: 3 | -0.10 m | Y=14.02 | X=22.25 | NNUK=3.10 m

# IfcFlowFitting: TP-121203-042 (2)
Type - Description: HT tee 87,5\X\B0 100x100; ApplicableOccurrence: Generic; PredefinedType: JUNCTION
Type - Pset_ManufacturerTypeInformation - ArticleNumber: TP-121203-042; ModelReference: HT tee 87,5\X\B0 100x100; Manufacturer: DDS
Type - Pset_PipeFittingTypeCommon - SubType: Junction Tee; NominalDiameter: 100, 100, 100; InnerDiameter: 104.6, 104.6, 104.6; OuterDiameter: 110, 110, 110
Material: IFC Building Material
Pset_DDS - Y: Y=11.21; Mounting Height: -0.13 m; Product: HT tee 87,5\X\B0 100x100; Medium: Sewer; Manufacturer: DDS; Pipe thickness:: x2.7; Dimension DN: 100 mm; X: X=22.25; Ins thickness: ins= 0.000000 mm; Length: 0.1 m; Product Number: TP-121203-042; Outside dimension: 109.999999; Rotation: 359.427338; Layer number: 178; Main string number: 00; Angle out: 90; Dimension out: 100; Dimension in: 100; Dimension tee: 100; Width: 100; Project name: OpenBIM; Height: 0; Insulation k-value: 0; Pressure drop: 0; Insulation WSVO: 0; Flow (m\X\B3/h): 0.0 m\X\B3/h; Flow (l/h): 0.000000 l/h; Part number: .000; Sub string number: .0000; Building Part: Building: 0; Flow (l/s): 0.00 l/s; Abs. pressure: 0.0 Pa; Velocity: 0.00 m/s
AC_Pset_RenovationAndPhasing - Renovation Status: Existing
Name | In | Mtg. Above Slab ref Center | Mtg. Below Ceiling ref Center | Above Sea Level ref. Center | Mtg. Below Ceiling ref Top | Model Number | Mtg. Above Slab ref Bottom | Floor number | Above Sea Level ref. Bottom | Room tekst | Mtg. above Finished Floor ref Center | Room number
Tee | 00 Ground floor | CC= -0.13m SSL | CC= 3.63m FCL | NN=-0.33 m | Top= 3.58m FCL | Dra.no: 1 | Edge= -0.18m SSL | Storey: 2 | NNUK=-0.43 m | Entrance | CC= -0.13m FFB | 00.01
Tee | 01 First floor | CC= -0.26m SSL | CC= 3.56m FCL | NN=3.17 m | Top= 3.51m FCL | Dra.no: 2 | Edge= -0.31m SSL | Storey: 3 | NNUK=3.07 m | Restaurant | CC= -0.26m FFB | 01.03

# IfcFlowFitting: TP-121203-054 (2)
Type - Description: HT tee 87,5\X\B0 125x100; ApplicableOccurrence: Generic; PredefinedType: JUNCTION
Type - Pset_ManufacturerTypeInformation - ArticleNumber: TP-121203-054; ModelReference: HT tee 87,5\X\B0 125x100; Manufacturer: DDS
Type - Pset_PipeFittingTypeCommon - SubType: Junction Tee; NominalDiameter: 125, 125, 100; InnerDiameter: 118.8, 118.8, 104.6; OuterDiameter: 125, 125, 110
Material: IFC Building Material
Pset_DDS - Y: Y=11.21; Rotation: 180.000000; Outside dimension: 125.000003; Medium: Sewer; Manufacturer: DDS; X: X=29.65; Width: 125; Dimension in: 125; Dimension out: 125; Ins thickness: ins= 0.000000 mm; Length: 0.1 m; Dimension DN: 125 mm; Pipe thickness:: x3.1; Layer number: 178; Main string number: 00; Angle out: 90; Dimension tee: 100; Project name: OpenBIM; Height: 0; Insulation k-value: 0; Pressure drop: 0; Insulation WSVO: 0; Flow (m\X\B3/h): 0.0 m\X\B3/h; Product: HT tee 87,5\X\B0 125x100; Flow (l/h): 0.000000 l/h; Product Number: TP-121203-054; Part number: .000; Sub string number: .0000; Mounting Height: -0.20 m; Building Part: Building: 0; Flow (l/s): 0.00 l/s; Abs. pressure: 0.0 Pa; Velocity: 0.00 m/s
AC_Pset_RenovationAndPhasing - Renovation Status: Existing
Name | In | Mtg. above Finished Floor ref Center | Above Sea Level ref. Bottom | Mtg. Below Ceiling ref Center | Mtg. Below Ceiling ref Top | Above Sea Level ref. Center | Mtg. Above Slab ref Bottom | Model Number | Floor number | Mtg. Above Slab ref Center
Tee | 00 Ground floor | CC= -0.33m FFB | NNUK=-0.52 m | CC= 3.63m FCL | Top= 3.57m FCL | NN=-0.40 m | Edge= -0.39m SSL | Dra.no: 1 | Storey: 2 | CC= -0.33m SSL | Pset_DDS - Room number: 00.27; Room tekst: Shaft
Tee | 01 First floor | CC= -0.20m FFB | NNUK=2.98 m | CC= 3.50m FCL | Top= 0.00m FCL | NN=3.10 m | Edge= -0.26m SSL | Dra.no: 2 | Storey: 3 | CC= -0.20m SSL

# IfcFlowFitting: TP-130308-302 (20)
Type - Description: Copper tee 90\X\B0 15/15/15; ApplicableOccurrence: Generic; PredefinedType: JUNCTION
Type - Pset_ManufacturerTypeInformation - ArticleNumber: TP-130308-302; ModelReference: Copper tee 90\X\B0 15/15/15; Manufacturer: DDS
Type - Pset_PipeFittingTypeCommon - SubType: Junction Tee; NominalDiameter: 12, 12, 12; InnerDiameter: 13, 13, 13; OuterDiameter: 15, 15, 15
Material: IFC Building Material
Pset_DDS - Pipe thickness:: x1.0; Manufacturer: DDS; Insulation product text: Pipe insulation; Dimension tee: 12; Dimension out: 12; Dimension in: 12; Width: 12; Product Number: TP-130308-302; Ins thickness: ins= 9.000000 mm; Insulation product number: ZP150/915; Product: Copper tee 90\X\B0 15/15/15; Dimension DN: 12 mm; Angle out: 90; Project name: OpenBIM; Height: 0; Insulation k-value: 0; Insulation WSVO: 0; Outside dimension: 15.000000; Building Part: Building: 0
AC_Pset_RenovationAndPhasing - Renovation Status: Existing
Name | In | Mounting Height | Mtg. Below Ceiling ref Center | Rotation | Main string number | Above Sea Level ref. Bottom | Mtg. above Finished Floor ref Center | Abs. pressure | Y | Mtg. Above Slab ref Center | Length | Room tekst | Part number | Model Number | Layer number | Sub string number | Flow (l/s) | Flow (l/h) | Flow (m\X\B3/h) | Floor number | Mtg. Above Slab ref Bottom | Above Sea Level ref. Center | Velocity | Room number | Mtg. Below Ceiling ref Top | Pressure drop | Medium = Group | X
1.25.1 | 00 Ground floor | 3.10 m | CC= 0.20m FCL | 180.000000 | 01 | NNUK=2.89 m | CC= 3.10m FFB | 88265.0 Pa | Y=12.21 | CC= 3.10m SSL | 0.0 m | wc | .001 | Dra.no: 1 | 2 | .0025 | 0.39 l/s | 1403.999949 l/h | 1.4 m\X\B3/h | Storey: 2 | Edge= 3.09m SSL | NN=2.90 m | 1.55 m/s | 00.06 | Top= 0.19m FCL | 25583 | Coldwater | X=18.90 | Pset_DDS - System Name: PW
1.26.1 | 00 Ground floor | 3.10 m | CC= 0.20m FCL | 180.000000 | 01 | NNUK=2.89 m | CC= 3.10m FFB | 84629.4 Pa | Y=13.29 | CC= 3.10m SSL | 12.0 m | wc | .001 | Dra.no: 1 | 2 | .0026 | 0.26 l/s | 935.999966 l/h | 0.9 m\X\B3/h | Storey: 2 | Edge= 3.09m SSL | NN=2.90 m | 0.98 m/s | 00.08 | Top= 0.19m FCL | 3636 | Coldwater | X=18.90 | Pset_DDS - System Name: PW
1.32.0 | 00 Ground floor | 3.10 m | CC= 0.20m FCL | 0.000000 | 01 | NNUK=2.89 m | CC= 3.10m FFB | 0.0 Pa | Y=13.50 | CC= 3.10m SSL | 12.0 m | corridor | .000 | Dra.no: 1 | 2 | .0032 | 0.34 l/s | 1223.999986 l/h | 1.2 m\X\B3/h | Storey: 2 | Edge= 3.09m SSL | NN=2.90 m | 2.00 m/s | 00.04 | Top= 0.19m FCL | 4058 | Coldwater | X=21.99 | Pset_DDS - System Name: PW
1.32.1 | 00 Ground floor | 3.10 m | CC= 0.20m FCL | 0.000000 | 01 | NNUK=2.89 m | CC= 3.10m FFB | 138190.5 Pa | Y=13.87 | CC= 3.10m SSL | 12.0 m | corridor | .001 | Dra.no: 1 | 2 | .0032 | 0.34 l/s | 1223.999986 l/h | 1.2 m\X\B3/h | Storey: 2 | Edge= 3.09m SSL | NN=2.90 m | 1.05 m/s | 00.04 | Top= 0.19m FCL | 4058 | Coldwater | X=21.99 | Pset_DDS - System Name: PW
1.34.0 | 00 Ground floor | 3.10 m | CC= 0.20m FCL | 0.000000 | 01 | NNUK=2.89 m | CC= 3.10m FFB | 0.0 Pa | Y=14.54 | CC= 3.10m SSL | 12.0 m | corridor | .000 | Dra.no: 1 | 2 | .0034 | 0.14 l/s | 504.000002 l/h | 0.5 m\X\B3/h | Storey: 2 | Edge= 3.09m SSL | NN=2.90 m | 1.05 m/s | 00.04 | Top= 0.19m FCL | 1297 | Coldwater | X=21.99 | Pset_DDS - System Name: PW
2.2.1 | 00 Ground floor | 3.18 m | CC= 0.32m FCL | 0.000000 | 02 | NNUK=2.96 m | CC= 3.18m FFB | 148404.7 Pa | Y=11.09 | CC= 3.18m SSL | 0.0 m | Entrance | .001 | Dra.no: 1 | 3 | .0002 | 0.35 l/s | 1260.000005 l/h | 1.3 m\X\B3/h | Storey: 2 | Edge= 3.17m SSL | NN=2.98 m | 1.67 m/s | 00.01 | Top= 0.32m FCL | 37075 | Hotwater | X=23.31
2.3.0 | 00 Ground floor | 3.18 m | CC= 0.12m FCL | 270.000000 | 02 | NNUK=2.96 m | CC= 3.18m FFB | 0.0 Pa | Y=14.74 | CC= 3.18m SSL | 12.0 m | corridor | .000 | Dra.no: 1 | 3 | .0003 | 0.28 l/s | 1008.000004 l/h | 1.0 m\X\B3/h | Storey: 2 | Edge= 3.17m SSL | NN=2.98 m | 1.67 m/s | 00.04 | Top= 0.12m FCL | 9386 | Hotwater | X=21.91
2.3.0 | 00 Ground floor | 3.18 m | CC= 0.12m FCL | 270.000000 | 02 | NNUK=2.96 m | CC= 3.18m FFB | 0.0 Pa | Y=13.70 | CC= 3.18m SSL | 12.0 m | corridor | .000 | Dra.no: 1 | 3 | .0003 | 0.28 l/s | 1008.000004 l/h | 1.0 m\X\B3/h | Storey: 2 | Edge= 3.17m SSL | NN=2.98 m | 1.67 m/s | 00.04 | Top= 0.12m FCL | 9386 | Hotwater | X=21.91
2.3.0 | 00 Ground floor | 3.18 m | CC= 0.12m FCL | 270.000000 | 02 | NNUK=2.96 m | CC= 3.18m FFB | 0.0 Pa | Y=12.66 | CC= 3.18m SSL | 12.0 m | corridor | .000 | Dra.no: 1 | 3 | .0003 | 0.28 l/s | 1008.000004 l/h | 1.0 m\X\B3/h | Storey: 2 | Edge= 3.17m SSL | NN=2.98 m | 1.67 m/s | 00.04 | Top= 0.12m FCL | 9386 | Hotwater | X=21.91
2.3.1 | 00 Ground floor | 3.18 m | CC= 0.12m FCL | 225.000000 | 02 | NNUK=2.96 m | CC= 3.18m FFB | 134869.3 Pa | Y=15.07 | CC= 3.18m SSL | 12.0 m | wc | .001 | Dra.no: 1 | 3 | .0003 | 0.28 l/s | 1008.000004 l/h | 1.0 m\X\B3/h | Storey: 2 | Edge= 3.17m SSL | NN=2.98 m | 0.53 m/s | 00.09 | Top= 0.12m FCL | 9386 | Hotwater | X=23.11
1.13.1 | 01 First floor | 2.80 m | CC= 0.63m FCL | 90.000000 | 01 | NNUK=6.09 m | CC= 2.67m FFB | 174566.3 Pa | Y=13.50 | CC= 2.67m SSL | 0.0 m | corridor | .001 | Dra.no: 2 | 2 | .0013 | 0.34 l/s | 1223.999986 l/h | 1.2 m\X\B3/h | Storey: 3 | Edge= 2.66m SSL | NN=6.10 m | 1.61 m/s | 01.04 | Top= 0.62m FCL | 4225 | Coldwater | X=22.16 | Pset_DDS - System Name: PW
1.14.1 | 01 First floor | 2.80 m | CC= 0.63m FCL | 0.000000 | 01 | NNUK=6.09 m | CC= 2.67m FFB | 172516.1 Pa | Y=13.86 | CC= 2.67m SSL | 0.0 m | corridor | .001 | Dra.no: 2 | 2 | .0014 | 0.27 l/s | 971.999985 l/h | 1.0 m\X\B3/h | Storey: 3 | Edge= 2.66m SSL | NN=6.10 m | 1.05 m/s | 01.04 | Top= 0.62m FCL | 2050 | Coldwater | X=22.16 | Pset_DDS - System Name: PW
1.15.1 | 01 First floor | 2.80 m | CC= 0.63m FCL | 90.000000 | 01 | NNUK=6.09 m | CC= 2.67m FFB | 171184.2 Pa | Y=14.54 | CC= 2.67m SSL | 12.0 m | corridor | .001 | Dra.no: 2 | 2 | .0015 | 0.14 l/s | 504.000002 l/h | 0.5 m\X\B3/h | Storey: 3 | Edge= 2.66m SSL | NN=6.10 m | 0.53 m/s | 01.04 | Top= 0.62m FCL | 1332 | Coldwater | X=22.16 | Pset_DDS - System Name: PW
1.6.1 | 01 First floor | 2.80 m | CC= 0.63m FCL | 180.000000 | 01 | NNUK=6.09 m | CC= 2.67m FFB | 122596.3 Pa | Y=12.24 | CC= 2.67m SSL | 0.0 m | wc | .001 | Dra.no: 2 | 2 | .0006 | 0.26 l/s | 935.999966 l/h | 0.9 m\X\B3/h | Storey: 3 | Edge= 2.66m SSL | NN=6.10 m | 1.55 m/s | 01.07 | Top= 0.62m FCL | 13548 | Coldwater | X=18.95 | Pset_DDS - System Name: PW
1.7.1 | 01 First floor | 2.80 m | CC= 0.63m FCL | 180.000000 | 01 | NNUK=6.09 m | CC= 2.67m FFB | 119003.3 Pa | Y=13.31 | CC= 2.67m SSL | 12.0 m | wc | .001 | Dra.no: 2 | 2 | .0007 | 0.26 l/s | 935.999966 l/h | 0.9 m\X\B3/h | Storey: 3 | Edge= 2.66m SSL | NN=6.10 m | 0.98 m/s | 01.09 | Top= 0.62m FCL | 3593 | Coldwater | X=18.95 | Pset_DDS - System Name: PW
2.12.1 | 01 First floor | 2.88 m | CC= 0.56m FCL | 0.000000 | 02 | NNUK=6.16 m | CC= 2.75m FFB | 181991.0 Pa | Y=11.09 | CC= 2.75m SSL | 0.0 m | Restaurant | .001 | Dra.no: 2 | 3 | .0012 | 0.35 l/s | 1260.000005 l/h | 1.3 m\X\B3/h | Storey: 3 | Edge= 2.74m SSL | NN=6.18 m | 1.67 m/s | 01.03 | Top= 0.55m FCL | 22082 | Hotwater | X=23.31
2.13.1 | 01 First floor | 2.88 m | CC= 0.56m FCL | 270.000000 | 02 | NNUK=6.16 m | CC= 2.75m FFB | 172744.5 Pa | Y=12.66 | CC= 2.75m SSL | 0.0 m | corridor | .001 | Dra.no: 2 | 3 | .0013 | 0.28 l/s | 1008.000004 l/h | 1.0 m\X\B3/h | Storey: 3 | Edge= 2.74m SSL | NN=6.18 m | 1.21 m/s | 01.04 | Top= 0.55m FCL | 9246 | Hotwater | X=22.04
2.14.1 | 01 First floor | 2.88 m | CC= 0.56m FCL | 270.000000 | 02 | NNUK=6.16 m | CC= 2.75m FFB | 170911.6 Pa | Y=13.70 | CC= 2.75m SSL | 12.0 m | corridor | .001 | Dra.no: 2 | 3 | .0014 | 0.21 l/s | 756.000003 l/h | 0.8 m\X\B3/h | Storey: 3 | Edge= 2.74m SSL | NN=6.18 m | 1.05 m/s | 01.04 | Top= 0.55m FCL | 1833 | Hotwater | X=22.04
2.15.1 | 01 First floor | 2.88 m | CC= 0.56m FCL | 270.000000 | 02 | NNUK=6.16 m | CC= 2.75m FFB | 169480.5 Pa | Y=14.74 | CC= 2.75m SSL | 12.0 m | corridor | .001 | Dra.no: 2 | 3 | .0015 | 0.14 l/s | 504.000002 l/h | 0.5 m\X\B3/h | Storey: 3 | Edge= 2.74m SSL | NN=6.18 m | 0.53 m/s | 01.04 | Top= 0.55m FCL | 1431 | Hotwater | X=22.04
2.16.1 | 01 First floor | 2.88 m | CC= 0.56m FCL | 270.000000 | 02 | NNUK=6.16 m | CC= 2.75m FFB | 168531.1 Pa | Y=15.11 | CC= 2.75m SSL | 12.0 m | wc | .001 | Dra.no: 2 | 3 | .0016 | 0.07 l/s | 252.000001 l/h | 0.3 m\X\B3/h | Storey: 3 | Edge= 2.74m SSL | NN=6.18 m | 0.53 m/s | 01.11 | Top= 0.55m FCL | 949 | Hotwater | X=23.11

# IfcFlowFitting: TP-130308-304 (11)
Type - Description: Copper tee 90\X\B0 18/15/18; ApplicableOccurrence: Generic; PredefinedType: JUNCTION
Type - Pset_ManufacturerTypeInformation - ArticleNumber: TP-130308-304; ModelReference: Copper tee 90\X\B0 18/15/18; Manufacturer: DDS
Type - Pset_PipeFittingTypeCommon - SubType: Junction Tee; NominalDiameter: 15, 15, 12; InnerDiameter: 16, 16, 13; OuterDiameter: 18, 18, 15
Material: IFC Building Material
Pset_DDS - Pipe thickness:: x1.0; Manufacturer: DDS; Dimension tee: 12; Product Number: TP-130308-304; Outside dimension: 18.000000; Product: Copper tee 90\X\B0 18/15/18; Angle out: 90; Project name: OpenBIM; Height: 0; Insulation k-value: 0; Insulation WSVO: 0; Dimension in: 15; Dimension out: 15; Width: 15; Dimension DN: 15 mm; Building Part: Building: 0
AC_Pset_RenovationAndPhasing - Renovation Status: Existing
Name | In | Flow (l/s) | Mounting Height | X | Insulation product text | Mtg. Below Ceiling ref Center | Main string number | Sub string number | Flow (l/h) | Above Sea Level ref. Bottom | Mtg. above Finished Floor ref Center | Ins thickness | Mtg. Above Slab ref Center | Length | Insulation product number | System Name | Y | Model Number | Layer number | Flow (m\X\B3/h) | Floor number | Mtg. Above Slab ref Bottom | Room tekst | Above Sea Level ref. Center | Pressure drop | Part number | Room number | Velocity | Mtg. Below Ceiling ref Top | Rotation | Medium | Abs. pressure | Group
1.30.0 | 00 Ground floor | 0.54 l/s | 3.10 m | X=21.99 | Pipe insulation | CC= 0.20m FCL | 01 | .0030 | 1943.999970 l/h | NNUK=2.89 m | CC= 3.10m FFB | ins= 9.000000 mm | CC= 3.10m SSL | 0.0 m | ZP150/918 | PW | Y=12.46 | Dra.no: 1 | 2 | 1.9 m\X\B3/h | Storey: 2 | Edge= 3.09m SSL | corridor | NN=2.90 m | 7829 | .000 | 00.04 | 1.87 m/s | Top= 0.19m FCL | 0.000000 | Coldwater | 0.0 Pa | Coldwater
1.30.3 | 00 Ground floor | 0.54 l/s | 3.10 m | X=21.99 | Pipe insulation | CC= 0.20m FCL | 01 | .0030 | 1943.999970 l/h | NNUK=2.89 m | CC= 3.10m FFB | ins= 9.000000 mm | CC= 3.10m SSL | 12.0 m | ZP150/918 | PW | Y=12.76 | Dra.no: 1 | 2 | 1.9 m\X\B3/h | Storey: 2 | Edge= 3.09m SSL | corridor | NN=2.90 m | 7829 | .003 | 00.04 | 2.00 m/s | Top= 0.19m FCL | 0.000000 | Coldwater | 144299.1 Pa | Coldwater
2.2.0 | 00 Ground floor | 0.00 l/s | 2.90 m | X=35.55 |  | CC= 0.28m FCL | 02 | .0002 | 0.000000 l/h | NNUK=2.69 m | CC= 3.02m FFB | ins= 0.000000 mm | CC= 3.02m SSL | 0.0 m |  | Cooling | Y=20.48 | Dra.no: 1 | 188 | 0.0 m\X\B3/h | Storey: 2 | Edge= 3.01m SSL | Office | NN=2.70 m | 0 | .000 | 00.23 | 0.00 m/s | Top= 0.27m FCL | 0.000000 | Cooling Flow | 0.0 Pa | Cooling flow
2.5.1 | 00 Ground floor | 0.00 l/s | 3.10 m | X=35.55 |  | CC= 0.08m FCL | 02 | .0005 | 0.000000 l/h | NNUK=2.88 m | CC= 3.22m FFB | ins= 0.000000 mm | CC= 3.22m SSL | 12.0 m |  | Cooling | Y=16.85 | Dra.no: 1 | 188 | 0.0 m\X\B3/h | Storey: 2 | Edge= 3.21m SSL | Office | NN=2.90 m | 0 | .001 | 00.23 | 0.00 m/s | Top= 0.07m FCL | 359.982284 | Cooling Flow | 0.0 Pa | Cooling flow
3.2.0 | 00 Ground floor | 0.00 l/s | 3.00 m | X=35.49 |  | CC= 0.18m FCL | 03 | .0002 | 0.000000 l/h | NNUK=2.79 m | CC= 3.12m FFB | ins= 0.000000 mm | CC= 3.12m SSL | 0.0 m |  | Cooling | Y=20.42 | Dra.no: 1 | 189 | 0.0 m\X\B3/h | Storey: 2 | Edge= 3.11m SSL | Office | NN=2.80 m | 0 | .000 | 00.23 | 0.00 m/s | Top= 0.17m FCL | 0.000000 | Cooling return | 0.0 Pa | Cooling return
3.5.1 | 00 Ground floor | 0.00 l/s | 3.00 m | X=35.49 |  | CC= 0.18m FCL | 03 | .0005 | 0.000000 l/h | NNUK=2.79 m | CC= 3.12m FFB | ins= 0.000000 mm | CC= 3.12m SSL | 12.0 m |  | Cooling | Y=16.78 | Dra.no: 1 | 189 | 0.0 m\X\B3/h | Storey: 2 | Edge= 3.11m SSL | Office | NN=2.80 m | 0 | .001 | 00.23 | 0.00 m/s | Top= 0.17m FCL | 0.000000 | Cooling return | 0.0 Pa | Cooling return
1.11.1 | 01 First floor | 0.54 l/s | 2.80 m | X=22.16 | Pipe insulation | CC= 0.63m FCL | 01 | .0011 | 1943.999970 l/h | NNUK=6.09 m | CC= 2.67m FFB | ins= 9.000000 mm | CC= 2.67m SSL | 0.0 m | ZP150/918 | PW | Y=12.46 | Dra.no: 2 | 2 | 1.9 m\X\B3/h | Storey: 3 | Edge= 2.66m SSL | corridor | NN=6.10 m | 7875 | .001 | 01.04 | 1.70 m/s | Top= 0.62m FCL | 90.000000 | Coldwater | 180357.2 Pa | Coldwater
1.12.3 | 01 First floor | 0.47 l/s | 2.80 m | X=22.16 | Pipe insulation | CC= 0.63m FCL | 01 | .0012 | 1691.999969 l/h | NNUK=6.09 m | CC= 2.67m FFB | ins= 9.000000 mm | CC= 2.67m SSL | 12.0 m | ZP150/918 | PW | Y=12.73 | Dra.no: 2 | 2 | 1.7 m\X\B3/h | Storey: 3 | Edge= 2.66m SSL | corridor | NN=6.10 m | 1566 | .003 | 01.04 | 2.00 m/s | Top= 0.62m FCL | 0.000000 | Coldwater | 178791.0 Pa | Coldwater
1.4.1 | 01 First floor | 0.87 l/s | 2.80 m | X=23.11 | Pipe insulation | CC= 0.63m FCL | 01 | .0004 | 3131.999937 l/h | NNUK=6.09 m | CC= 2.67m FFB | ins= 9.000000 mm | CC= 2.67m SSL | 0.0 m | ZP150/918 | PW | Y=10.94 | Dra.no: 2 | 2 | 3.1 m\X\B3/h | Storey: 3 | Edge= 2.66m SSL | Restaurant | NN=6.10 m | 33556 | .001 | 01.03 | 2.38 m/s | Top= 0.62m FCL | 0.000000 | Coldwater | 193936.7 Pa | Coldwater
2.1.6 | 01 First floor | 0.70 l/s | 2.88 m | X=29.36 | Pipe insulation | CC= 0.43m FCL | 02 | .0001 | 2520.000011 l/h | NNUK=6.16 m | CC= 2.88m FFB | ins= 9.000000 mm | CC= 2.88m SSL | 0.1 m | ZP150/918 |  | Y=11.09 | Dra.no: 2 | 3 | 2.5 m\X\B3/h | Storey: 3 | Edge= 2.87m SSL |  | NN=6.18 m | 72106 | .006 |  | 2.05 m/s | Top= 0.00m FCL | 90.000000 | Hotwater | 185479.5 Pa | Hotwater
3.1.9 | 01 First floor | 0.08 l/s | 2.95 m | X=29.36 | Pipe insulation | CC= 0.35m FCL | 03 | .0001 | 282.908085 l/h | NNUK=6.24 m | CC= 2.95m FFB | ins= 9.000000 mm | CC= 2.95m SSL | 0.1 m | ZP150/918 |  | Y=11.33 | Dra.no: 2 | 4 | 0.3 m\X\B3/h | Storey: 3 | Edge= 2.94m SSL |  | NN=6.25 m | 3343 | .009 |  | 0.32 m/s | Top= 0.00m FCL | 90.000000 | Circulation | 2413.1 Pa | Circulation

# IfcFlowFitting: TP-130308-305 (2)
In: 01 First floor
Type - Description: Copper tee 90\X\B0 18/18/18; ApplicableOccurrence: Generic; PredefinedType: JUNCTION
Type - Pset_ManufacturerTypeInformation - ArticleNumber: TP-130308-305; ModelReference: Copper tee 90\X\B0 18/18/18; Manufacturer: DDS
Type - Pset_PipeFittingTypeCommon - SubType: Junction Tee; NominalDiameter: 15, 15, 15; InnerDiameter: 16, 16, 16; OuterDiameter: 18, 18, 18
Material: IFC Building Material; Group: Coldwater
Pset_DDS - Mounting Height: 2.80 m; Pipe thickness:: x1.0; Insulation product text: Pipe insulation; Main string number: 01; Manufacturer: DDS; Product Number: TP-130308-305; Ins thickness: ins= 9.000000 mm; Above Sea Level ref. Bottom: NNUK=6.09 m; Above Sea Level ref. Center: NN=6.10 m; Insulation product number: ZP150/918; Outside dimension: 18.000000; Y: Y=10.94; System Name: PW; Model Number: Dra.no: 2; Layer number: 2; Angle out: 90; Project name: OpenBIM; Height: 0; Insulation k-value: 0; Insulation WSVO: 0; Product: Copper tee 90\X\B0 18/18/18; Floor number: Storey: 3; Dimension tee: 15; Dimension in: 15; Dimension out: 15; Width: 15; Dimension DN: 15 mm; Building Part: Building: 0; Medium: Coldwater
AC_Pset_RenovationAndPhasing - Renovation Status: Existing
Name | Flow (l/h) | Part number | Mtg. Below Ceiling ref Center | Mtg. above Finished Floor ref Center | Mtg. Above Slab ref Center | Length | Rotation | Pressure drop | X | Velocity | Flow (m\X\B3/h) | Mtg. Above Slab ref Bottom | Sub string number | Flow (l/s) | Mtg. Below Ceiling ref Top | Abs. pressure
1.2.3 | 3131.999937 l/h | .003 | CC= 0.50m FCL | CC= 2.80m FFB | CC= 2.80m SSL | 0.1 m | 270.000003 | 16914 | X=29.36 | 2.49 m/s | 3.1 m\X\B3/h | Edge= 2.79m SSL | .0002 | 0.87 l/s | Top= 0.00m FCL | 0.0 Pa
1.5.4 | 2879.999936 l/h | .004 | CC= 0.63m FCL | CC= 2.67m FFB | CC= 2.67m SSL | 0.0 m | 0.000000 | 5704 | X=22.16 | 1.55 m/s | 2.9 m\X\B3/h | Edge= 2.66m SSL | .0005 | 0.80 l/s | Top= 0.62m FCL | 136144.2 Pa | Pset_DDS - Room number: 01.03; Room tekst: Restaurant

# IfcFlowFitting: TP-130308-306, 1.23.1
In: 00 Ground floor
Type - Description: Copper tee 90\X\B0 22/15/22; ApplicableOccurrence: Generic; PredefinedType: JUNCTION
Type - Pset_ManufacturerTypeInformation - ArticleNumber: TP-130308-306; ModelReference: Copper tee 90\X\B0 22/15/22; Manufacturer: DDS
Type - Pset_PipeFittingTypeCommon - SubType: Junction Tee; NominalDiameter: 20, 20, 12; InnerDiameter: 20, 20, 13; OuterDiameter: 22, 22, 15
Material: IFC Building Material; Group: Coldwater
Pset_DDS - X: X=23.11; Mounting Height: 3.10 m; Pipe thickness:: x1.0; Dimension DN: 20 mm; Product: Copper tee 90\X\B0 22/15/22; Mtg. Below Ceiling ref Center: CC= 0.40m FCL; Main string number: 01; Above Sea Level ref. Bottom: NNUK=2.88 m; Mtg. above Finished Floor ref Center: CC= 3.10m FFB; Manufacturer: DDS; Dimension tee: 12; Product Number: TP-130308-306; Ins thickness: ins= 9.000000 mm; Mtg. Above Slab ref Center: CC= 3.10m SSL; Length: 0.0 m; Abs. pressure: 156391.5 Pa; Part number: .001; Y: Y=10.94; System Name: PW; Model Number: Dra.no: 1; Layer number: 2; Width: 20; Dimension in: 20; Dimension out: 20; Angle out: 90; Sub string number: .0023; Project name: OpenBIM; Flow (l/h): 3599.999920 l/h; Height: 0; Insulation k-value: 0; Insulation WSVO: 0; Outside dimension: 22.000000; Flow (m\X\B3/h): 3.6 m\X\B3/h; Floor number: Storey: 2; Mtg. Above Slab ref Bottom: Edge= 3.09m SSL; Above Sea Level ref. Center: NN=2.90 m; Room tekst: Entrance; Velocity: 1.65 m/s; Insulation product text: Pipe insulation; Room number: 00.01; Pressure drop: 12204; Rotation: 0.000000; Mtg. Below Ceiling ref Top: Top= 0.39m FCL; Building Part: Building: 0; Medium: Coldwater; Flow (l/s): 1.00 l/s; Insulation product number: ZP150/922
AC_Pset_RenovationAndPhasing - Renovation Status: Existing

# IfcFlowFitting: TP-130308-307 (31)
Type - Description: Copper tee 90\X\B0 22/18/22; ApplicableOccurrence: Generic; PredefinedType: JUNCTION
Type - Pset_ManufacturerTypeInformation - ArticleNumber: TP-130308-307; ModelReference: Copper tee 90\X\B0 22/18/22; Manufacturer: DDS
Type - Pset_PipeFittingTypeCommon - SubType: Junction Tee; NominalDiameter: 20, 20, 15; InnerDiameter: 20, 20, 16; OuterDiameter: 22, 22, 18
Material: IFC Building Material
Pset_DDS - Pipe thickness:: x1.0; Dimension DN: 20 mm; Manufacturer: DDS; Product Number: TP-130308-307; Product: Copper tee 90\X\B0 22/18/22; Width: 20; Dimension in: 20; Dimension out: 20; Angle out: 90; Project name: OpenBIM; Height: 0; Insulation k-value: 0; Insulation WSVO: 0; Outside dimension: 22.000000; Dimension tee: 15; Building Part: Building: 0
AC_Pset_RenovationAndPhasing - Renovation Status: Existing
Name | In | Abs. pressure | Mounting Height | X | Velocity | Mtg. Below Ceiling ref Center | Main string number | Above Sea Level ref. Bottom | Mtg. above Finished Floor ref Center | Ins thickness | Mtg. Above Slab ref Center | Part number | Length | Y | Model Number | Layer number | Sub string number | Flow (l/h) | Flow (m\X\B3/h) | Floor number | Mtg. Above Slab ref Bottom | Above Sea Level ref. Center | Room tekst | Flow (l/s) | Room number | Rotation | Mtg. Below Ceiling ref Top | Medium | Pressure drop
1.24.4 | 00 Ground floor | 113847.8 Pa | 3.10 m | X=21.99 | 2.24 m/s | CC= 0.40m FCL | 01 | NNUK=2.88 m | CC= 3.10m FFB | ins= 9.000000 mm | CC= 3.10m SSL | .004 | 0.0 m | Y=10.94 | Dra.no: 1 | 2 | .0024 | 3347.999918 l/h | 3.3 m\X\B3/h | Storey: 2 | Edge= 3.09m SSL | NN=2.90 m | Entrance | 0.93 l/s | 00.01 | 0.000000 | Top= 0.39m FCL | Coldwater | 2662 | Pset_DDS - System Name: PW; Insulation product text: Pipe insulation; Insulation product number: ZP150/922; Group: Coldwater
2.1.0 | 00 Ground floor | 0.0 Pa | 2.80 m | X=32.17 | 0.00 m/s | CC= 0.50m FCL | 02 | NNUK=2.58 m | CC= 2.80m FFB | ins= 0.000000 mm | CC= 2.80m SSL | .000 | 0.0 m | Y=16.85 | Dra.no: 1 | 188 | .0001 | 0.000000 l/h | 0.0 m\X\B3/h | Storey: 2 | Edge= 2.79m SSL | NN=2.60 m | Hallway | 0.00 l/s | 00.03 | 90.000000 | Top= 0.49m FCL | Cooling Flow | 0 | Pset_DDS - System Name: Cooling; Group: Cooling flow
3.1.0 | 00 Ground floor | 0.0 Pa | 2.80 m | X=32.23 | 0.00 m/s | CC= 0.50m FCL | 03 | NNUK=2.58 m | CC= 2.80m FFB | ins= 0.000000 mm | CC= 2.80m SSL | .000 | 0.0 m | Y=16.78 | Dra.no: 1 | 189 | .0001 | 0.000000 l/h | 0.0 m\X\B3/h | Storey: 2 | Edge= 2.79m SSL | NN=2.60 m | Hallway | 0.00 l/s | 00.03 | 0.000000 | Top= 0.49m FCL | Cooling return | 0 | Pset_DDS - System Name: Cooling; Group: Cooling return
Tee | 00 Ground floor | 0.0 Pa | -0.20 m | X=30.32 | 0.00 m/s | CC= 3.50m FCL | 00 | NNUK=-0.42 m | CC= -0.20m FFB | ins= 0.000000 mm | CC= -0.20m SSL | .000 | 0.0 m | Y=22.09 | Dra.no: 1 | 5 | .0000 | 0.000000 l/h | 0.0 m\X\B3/h | Storey: 2 | Edge= -0.21m SSL | NN=-0.40 m | Hallway | 0.00 l/s | 00.03 | 180.000000 | Top= 3.49m FCL | Heat flow | 0
Tee | 00 Ground floor | 0.0 Pa | -0.10 m | X=38.30 | 0.00 m/s | CC= 3.28m FCL | 00 | NNUK=-0.32 m | CC= 0.02m FFB | ins= 0.000000 mm | CC= 0.02m SSL | .000 | 15.0 m | Y=7.27 | Dra.no: 1 | 6 | .0000 | 0.000000 l/h | 0.0 m\X\B3/h | Storey: 2 | Edge= 0.01m SSL | NN=-0.30 m | Director office | 0.00 l/s | 00.24 | 180.000000 | Top= 3.27m FCL | Heat return | 0
Tee | 00 Ground floor | 0.0 Pa | -0.20 m | X=35.39 | 0.00 m/s | CC= 3.38m FCL | 00 | NNUK=-0.42 m | CC= -0.08m FFB | ins= 0.000000 mm | CC= -0.08m SSL | .000 | 15.0 m | Y=22.09 | Dra.no: 1 | 5 | .0000 | 0.000000 l/h | 0.0 m\X\B3/h | Storey: 2 | Edge= -0.09m SSL | NN=-0.40 m | Office | 0.00 l/s | 00.23 | 180.000000 | Top= 3.37m FCL | Heat flow | 0
Tee | 00 Ground floor | 0.0 Pa | -0.10 m | X=30.37 | 0.00 m/s | CC= 3.40m FCL | 00 | NNUK=-0.32 m | CC= -0.10m FFB | ins= 0.000000 mm | CC= -0.10m SSL | .000 | 0.0 m | Y=21.96 | Dra.no: 1 | 6 | .0000 | 0.000000 l/h | 0.0 m\X\B3/h | Storey: 2 | Edge= -0.11m SSL | NN=-0.30 m | Hallway | 0.00 l/s | 00.03 | 180.000000 | Top= 3.39m FCL | Heat return | 0
Tee | 00 Ground floor | 0.0 Pa | -0.20 m | X=37.95 | 0.00 m/s | CC= 3.38m FCL | 00 | NNUK=-0.42 m | CC= -0.08m FFB | ins= 0.000000 mm | CC= -0.08m SSL | .000 | 15.0 m | Y=22.09 | Dra.no: 1 | 5 | .0000 | 0.000000 l/h | 0.0 m\X\B3/h | Storey: 2 | Edge= -0.09m SSL | NN=-0.40 m | Office | 0.00 l/s | 00.23 | 180.000000 | Top= 3.37m FCL | Heat flow | 0
Tee | 00 Ground floor | 0.0 Pa | -0.10 m | X=40.54 | 0.00 m/s | CC= 3.28m FCL | 00 | NNUK=-0.32 m | CC= 0.02m FFB | ins= 0.000000 mm | CC= 0.02m SSL | .000 | 15.0 m | Y=12.66 | Dra.no: 1 | 6 | .0000 | 0.000000 l/h | 0.0 m\X\B3/h | Storey: 2 | Edge= 0.01m SSL | NN=-0.30 m | Storage | 0.00 l/s | 00.12 | 180.000000 | Top= 3.27m FCL | Heat return | 0
Tee | 00 Ground floor | 0.0 Pa | -0.10 m | X=40.54 | 0.00 m/s | CC= 3.28m FCL | 00 | NNUK=-0.32 m | CC= 0.02m FFB | ins= 0.000000 mm | CC= 0.02m SSL | .000 | 15.0 m | Y=18.43 | Dra.no: 1 | 6 | .0000 | 0.000000 l/h | 0.0 m\X\B3/h | Storey: 2 | Edge= 0.01m SSL | NN=-0.30 m | Office | 0.00 l/s | 00.23 | 180.000000 | Top= 3.27m FCL | Heat return | 0
Tee | 00 Ground floor | 0.0 Pa | -0.20 m | X=40.65 | 0.00 m/s | CC= 3.38m FCL | 00 | NNUK=-0.42 m | CC= -0.08m FFB | ins= 0.000000 mm | CC= -0.08m SSL | .000 | 15.0 m | Y=18.48 | Dra.no: 1 | 5 | .0000 | 0.000000 l/h | 0.0 m\X\B3/h | Storey: 2 | Edge= -0.09m SSL | NN=-0.40 m | Office | 0.00 l/s | 00.23 | 180.000000 | Top= 3.37m FCL | Heat flow | 0
Tee | 00 Ground floor | 0.0 Pa | -0.20 m | X=40.65 | 0.00 m/s | CC= 3.38m FCL | 00 | NNUK=-0.42 m | CC= -0.08m FFB | ins= 0.000000 mm | CC= -0.08m SSL | .000 | 15.0 m | Y=12.71 | Dra.no: 1 | 5 | .0000 | 0.000000 l/h | 0.0 m\X\B3/h | Storey: 2 | Edge= -0.09m SSL | NN=-0.40 m | Storage | 0.00 l/s | 00.12 | 180.000000 | Top= 3.37m FCL | Heat flow | 0
Tee | 00 Ground floor | 0.0 Pa | -0.10 m | X=38.00 | 0.00 m/s | CC= 3.28m FCL | 00 | NNUK=-0.32 m | CC= 0.02m FFB | ins= 0.000000 mm | CC= 0.02m SSL | .000 | 15.0 m | Y=21.96 | Dra.no: 1 | 6 | .0000 | 0.000000 l/h | 0.0 m\X\B3/h | Storey: 2 | Edge= 0.01m SSL | NN=-0.30 m | Office | 0.00 l/s | 00.23 | 180.000000 | Top= 3.27m FCL | Heat return | 0
Tee | 00 Ground floor | 0.0 Pa | -0.10 m | X=35.44 | 0.00 m/s | CC= 3.28m FCL | 00 | NNUK=-0.32 m | CC= 0.02m FFB | ins= 0.000000 mm | CC= 0.02m SSL | .000 | 15.0 m | Y=21.96 | Dra.no: 1 | 6 | .0000 | 0.000000 l/h | 0.0 m\X\B3/h | Storey: 2 | Edge= 0.01m SSL | NN=-0.30 m | Office | 0.00 l/s | 00.23 | 180.000000 | Top= 3.27m FCL | Heat return | 0
Tee | 00 Ground floor | 0.0 Pa | -0.20 m | X=38.35 | 0.00 m/s | CC= 3.38m FCL | 00 | NNUK=-0.42 m | CC= -0.08m FFB | ins= 0.000000 mm | CC= -0.08m SSL | .000 | 15.0 m | Y=7.16 | Dra.no: 1 | 5 | .0000 | 0.000000 l/h | 0.0 m\X\B3/h | Storey: 2 | Edge= -0.09m SSL | NN=-0.40 m | Director office | 0.00 l/s | 00.24 | 180.000000 | Top= 3.37m FCL | Heat flow | 0
Tee | 01 First floor | 0.0 Pa | -0.20 m | X=18.32 | 0.00 m/s | CC= 3.38m FCL | 00 | NNUK=3.08 m | CC= -0.08m FFB | ins= 0.000000 mm | CC= -0.08m SSL | .000 | 15.0 m | Y=22.06 | Dra.no: 2 | 6 | .0000 | 0.000000 l/h | 0.0 m\X\B3/h | Storey: 3 | Edge= -0.09m SSL | NN=3.10 m | Office | 0.00 l/s | 01.19 | 0.000000 | Top= 3.37m FCL | Heat return | 0
Tee | 01 First floor | 0.0 Pa | -0.20 m | X=22.87 | 0.00 m/s | CC= 3.38m FCL | 00 | NNUK=3.08 m | CC= -0.08m FFB | ins= 0.000000 mm | CC= -0.08m SSL | .000 | 15.0 m | Y=22.06 | Dra.no: 2 | 6 | .0000 | 0.000000 l/h | 0.0 m\X\B3/h | Storey: 3 | Edge= -0.09m SSL | NN=3.10 m | Storage | 0.00 l/s | 01.13 | 0.000000 | Top= 3.37m FCL | Heat return | 0
Tee | 01 First floor | 0.0 Pa | -0.20 m | X=27.57 | 0.00 m/s | CC= 3.63m FCL | 00 | NNUK=3.08 m | CC= -0.33m FFB | ins= 0.000000 mm | CC= -0.33m SSL | .000 | 0.0 m | Y=22.06 | Dra.no: 2 | 6 | .0000 | 0.000000 l/h | 0.0 m\X\B3/h | Storey: 3 | Edge= -0.34m SSL | NN=3.10 m | Hallway | 0.00 l/s | 01.02 | 180.000000 | Top= 3.62m FCL | Heat return | 0
Tee | 01 First floor | 0.0 Pa | -0.20 m | X=25.32 | 0.00 m/s | CC= 3.63m FCL | 00 | NNUK=3.08 m | CC= -0.33m FFB | ins= 0.000000 mm | CC= -0.33m SSL | .000 | 0.0 m | Y=22.06 | Dra.no: 2 | 6 | .0000 | 0.000000 l/h | 0.0 m\X\B3/h | Storey: 3 | Edge= -0.34m SSL | NN=3.10 m | Hallway | 0.00 l/s | 01.02 | 0.000000 | Top= 3.62m FCL | Heat return | 0
Tee | 01 First floor | 0.0 Pa | -0.10 m | X=18.27 | 0.00 m/s | CC= 3.28m FCL | 00 | NNUK=3.18 m | CC= 0.02m FFB | ins= 0.000000 mm | CC= 0.02m SSL | .000 | 15.0 m | Y=22.18 | Dra.no: 2 | 5 | .0000 | 0.000000 l/h | 0.0 m\X\B3/h | Storey: 3 | Edge= 0.01m SSL | NN=3.20 m | Office | 0.00 l/s | 01.19 | 0.000000 | Top= 3.27m FCL | Heat flow | 0
Tee | 01 First floor | 0.0 Pa | -0.10 m | X=22.82 | 0.00 m/s | CC= 3.28m FCL | 00 | NNUK=3.18 m | CC= 0.02m FFB | ins= 0.000000 mm | CC= 0.02m SSL | .000 | 15.0 m | Y=22.18 | Dra.no: 2 | 5 | .0000 | 0.000000 l/h | 0.0 m\X\B3/h | Storey: 3 | Edge= 0.01m SSL | NN=3.20 m | Storage | 0.00 l/s | 01.13 | 0.000000 | Top= 3.27m FCL | Heat flow | 0
Tee | 01 First floor | 0.0 Pa | -0.20 m | X=16.07 | 0.00 m/s | CC= 3.38m FCL | 00 | NNUK=3.08 m | CC= -0.08m FFB | ins= 0.000000 mm | CC= -0.08m SSL | .000 | 15.0 m | Y=22.06 | Dra.no: 2 | 6 | .0000 | 0.000000 l/h | 0.0 m\X\B3/h | Storey: 3 | Edge= -0.09m SSL | NN=3.10 m | Office | 0.00 l/s | 01.20 | 0.000000 | Top= 3.37m FCL | Heat return | 0
Tee | 01 First floor | 0.0 Pa | -0.10 m | X=25.27 | 0.00 m/s | CC= 3.53m FCL | 00 | NNUK=3.18 m | CC= -0.23m FFB | ins= 0.000000 mm | CC= -0.23m SSL | .000 | 0.0 m | Y=22.18 | Dra.no: 2 | 5 | .0000 | 0.000000 l/h | 0.0 m\X\B3/h | Storey: 3 | Edge= -0.24m SSL | NN=3.20 m | Hallway | 0.00 l/s | 01.02 | 0.000000 | Top= 3.52m FCL | Heat flow | 0
Tee | 01 First floor | 0.0 Pa | -0.20 m | X=11.57 | 0.00 m/s | CC= 3.38m FCL | 00 | NNUK=3.08 m | CC= -0.08m FFB | ins= 0.000000 mm | CC= -0.08m SSL | .000 | 15.0 m | Y=22.06 | Dra.no: 2 | 6 | .0000 | 0.000000 l/h | 0.0 m\X\B3/h | Storey: 3 | Edge= -0.09m SSL | NN=3.10 m | Office | 0.00 l/s | 01.18 | 0.000000 | Top= 3.37m FCL | Heat return | 0
Tee | 01 First floor | 0.0 Pa | -0.10 m | X=16.02 | 0.00 m/s | CC= 3.28m FCL | 00 | NNUK=3.18 m | CC= 0.02m FFB | ins= 0.000000 mm | CC= 0.02m SSL | .000 | 15.0 m | Y=22.18 | Dra.no: 2 | 5 | .0000 | 0.000000 l/h | 0.0 m\X\B3/h | Storey: 3 | Edge= 0.01m SSL | NN=3.20 m | Office | 0.00 l/s | 01.20 | 0.000000 | Top= 3.27m FCL | Heat flow | 0
Tee | 01 First floor | 0.0 Pa | -0.20 m | X=7.37 | 0.00 m/s | CC= 3.63m FCL | 00 | NNUK=3.08 m | CC= -0.33m FFB | ins= 0.000000 mm | CC= -0.33m SSL | .000 | 15.0 m | Y=22.06 | Dra.no: 2 | 6 | .0000 | 0.000000 l/h | 0.0 m\X\B3/h | Storey: 3 | Edge= -0.34m SSL | NN=3.10 m | Staircase | 0.00 l/s | 01.05 | 0.000000 | Top= 3.62m FCL | Heat return | 0
Tee | 01 First floor | 0.0 Pa | -0.10 m | X=11.52 | 0.00 m/s | CC= 3.28m FCL | 00 | NNUK=3.18 m | CC= 0.02m FFB | ins= 0.000000 mm | CC= 0.02m SSL | .000 | 15.0 m | Y=22.18 | Dra.no: 2 | 5 | .0000 | 0.000000 l/h | 0.0 m\X\B3/h | Storey: 3 | Edge= 0.01m SSL | NN=3.20 m | Office | 0.00 l/s | 01.18 | 0.000000 | Top= 3.27m FCL | Heat flow | 0
Tee | 01 First floor | 0.0 Pa | -0.20 m | X=5.65 | 0.00 m/s | CC= 3.63m FCL | 00 | NNUK=3.08 m | CC= -0.33m FFB | ins= 0.000000 mm | CC= -0.33m SSL | .000 | 15.0 m | Y=14.47 | Dra.no: 2 | 6 | .0000 | 0.000000 l/h | 0.0 m\X\B3/h | Storey: 3 | Edge= -0.34m SSL | NN=3.10 m | Office | 0.00 l/s | 01.17 | 0.000000 | Top= 3.62m FCL | Heat return | 0
Tee | 01 First floor | 0.0 Pa | -0.10 m | X=7.32 | 0.00 m/s | CC= 3.53m FCL | 00 | NNUK=3.18 m | CC= -0.23m FFB | ins= 0.000000 mm | CC= -0.23m SSL | .000 | 15.0 m | Y=22.18 | Dra.no: 2 | 5 | .0000 | 0.000000 l/h | 0.0 m\X\B3/h | Storey: 3 | Edge= -0.24m SSL | NN=3.20 m | Staircase | 0.00 l/s | 01.05 | 0.000000 | Top= 3.52m FCL | Heat flow | 0
Tee | 01 First floor | 0.0 Pa | -0.10 m | X=27.52 | 0.00 m/s | CC= 3.53m FCL | 00 | NNUK=3.18 m | CC= -0.23m FFB | ins= 0.000000 mm | CC= -0.23m SSL | .000 | 0.0 m | Y=22.18 | Dra.no: 2 | 5 | .0000 | 0.000000 l/h | 0.0 m\X\B3/h | Storey: 3 | Edge= -0.24m SSL | NN=3.20 m | Hallway | 0.00 l/s | 01.02 | 180.000000 | Top= 3.52m FCL | Heat flow | 0
Tee | 01 First floor | 0.0 Pa | -0.10 m | X=5.51 | 0.00 m/s | CC= 3.53m FCL | 00 | NNUK=3.18 m | CC= -0.23m FFB | ins= 0.000000 mm | CC= -0.23m SSL | .000 | 15.0 m | Y=14.42 | Dra.no: 2 | 5 | .0000 | 0.000000 l/h | 0.0 m\X\B3/h | Storey: 3 | Edge= -0.24m SSL | NN=3.20 m | Office | 0.00 l/s | 01.17 | 0.000000 | Top= 3.52m FCL | Heat flow | 0

# IfcFlowFitting: TP-130308-308 (2)
In: 01 First floor
Type - Description: Copper tee 90\X\B0 22/22/22; ApplicableOccurrence: Generic; PredefinedType: JUNCTION
Type - Pset_ManufacturerTypeInformation - ArticleNumber: TP-130308-308; ModelReference: Copper tee 90\X\B0 22/22/22; Manufacturer: DDS
Type - Pset_PipeFittingTypeCommon - SubType: Junction Cross; NominalDiameter: 20, 20, 20; InnerDiameter: 20, 20, 20; OuterDiameter: 22, 22, 22
Material: IFC Building Material
Pset_DDS - Pipe thickness:: x1.0; Dimension DN: 20 mm; Room number: 01.02; Product: Copper tee 90\X\B0 22/22/22; Manufacturer: DDS; Product Number: TP-130308-308; Ins thickness: ins= 0.000000 mm; Model Number: Dra.no: 2; Width: 20; Main string number: 00; Dimension in: 20; Dimension out: 20; Dimension tee: 20; Angle out: 90; Project name: OpenBIM; Height: 0; Insulation k-value: 0; Pressure drop: 0; Insulation WSVO: 0; Outside dimension: 22.000000; Flow (m\X\B3/h): 0.0 m\X\B3/h; Floor number: Storey: 3; Flow (l/h): 0.000000 l/h; Length: 20.0 m; Part number: .000; Room tekst: Hallway; Sub string number: .0000; Rotation: 0.000000; Building Part: Building: 0; Flow (l/s): 0.00 l/s; Abs. pressure: 0.0 Pa; Velocity: 0.00 m/s
AC_Pset_RenovationAndPhasing - Renovation Status: Existing
Name | Y | Mtg. above Finished Floor ref Center | Mtg. Below Ceiling ref Center | Above Sea Level ref. Bottom | Mtg. Above Slab ref Bottom | Layer number | X | Mtg. Above Slab ref Center | Mounting Height | Above Sea Level ref. Center | Medium | Mtg. Below Ceiling ref Top
Tee | Y=22.06 | CC= -0.33m FFB | CC= 3.63m FCL | NNUK=3.08 m | Edge= -0.34m SSL | 6 | X=25.50 | CC= -0.33m SSL | -0.20 m | NN=3.10 m | Heat return | Top= 3.62m FCL
Tee | Y=22.18 | CC= -0.23m FFB | CC= 3.53m FCL | NNUK=3.18 m | Edge= -0.24m SSL | 5 | X=25.60 | CC= -0.23m SSL | -0.10 m | NN=3.20 m | Heat flow | Top= 3.52m FCL

# IfcFlowFitting: TP-130308-308, 1.1.5
In: 00 Ground floor
Type - Description: Copper tee 90\X\B0 22/22/22; ApplicableOccurrence: Generic; PredefinedType: JUNCTION
Type - Pset_ManufacturerTypeInformation - ArticleNumber: TP-130308-308; ModelReference: Copper tee 90\X\B0 22/22/22; Manufacturer: DDS
Type - Pset_PipeFittingTypeCommon - SubType: Junction Tee; NominalDiameter: 20, 20, 20; InnerDiameter: 20, 20, 20; OuterDiameter: 22, 22, 22
Material: IFC Building Material; Group: Coldwater
Pset_DDS - Mounting Height: 3.10 m; Pipe thickness:: x1.0; Dimension DN: 20 mm; Mtg. Below Ceiling ref Center: CC= 0.33m FCL; Rotation: 180.000000; Flow (l/h): 6731.999856 l/h; Main string number: 01; Product: Copper tee 90\X\B0 22/22/22; Above Sea Level ref. Bottom: NNUK=2.88 m; Manufacturer: DDS; Product Number: TP-130308-308; Ins thickness: ins= 9.000000 mm; Abs. pressure: 244406.6 Pa; Length: 0.1 m; Mtg. above Finished Floor ref Center: CC= 2.97m FFB; Y: Y=10.94; X: X=29.36; System Name: PW; Model Number: Dra.no: 1; Mtg. Above Slab ref Bottom: Edge= 2.96m SSL; Layer number: 2; Velocity: 2.49 m/s; Width: 20; Dimension in: 20; Dimension out: 20; Dimension tee: 20; Angle out: 90; Room number: 00.27; Project name: OpenBIM; Room tekst: Shaft; Height: 0; Insulation k-value: 0; Insulation WSVO: 0; Mtg. Above Slab ref Center: CC= 2.97m SSL; Outside dimension: 22.000000; Flow (m\X\B3/h): 6.7 m\X\B3/h; Floor number: Storey: 2; Above Sea Level ref. Center: NN=2.90 m; Pressure drop: 106751; Insulation product text: Pipe insulation; Sub string number: .0001; Flow (l/s): 1.87 l/s; Mtg. Below Ceiling ref Top: Top= 0.32m FCL; Building Part: Building: 0; Part number: .005; Medium: Coldwater; Insulation product number: ZP150/922
AC_Pset_RenovationAndPhasing - Renovation Status: Existing

# IfcFlowFitting: TP-130308-311 (2)
In: 02 Second floor
Type - Description: Copper tee 90\X\B0 28/28/28; ApplicableOccurrence: Generic; PredefinedType: JUNCTION
Type - Pset_ManufacturerTypeInformation - ArticleNumber: TP-130308-311; ModelReference: Copper tee 90\X\B0 28/28/28; Manufacturer: DDS
Type - Pset_PipeFittingTypeCommon - SubType: Junction Tee; NominalDiameter: 25, 25, 25; InnerDiameter: 25, 25, 25; OuterDiameter: 28, 28, 28
Material: IFC Building Material
Pset_DDS - Mounting Height: 0.40 m; Mtg. Below Ceiling ref Center: CC= 3.03m FCL; Above Sea Level ref. Bottom: NNUK=7.18 m; Rotation: 180.000000; Manufacturer: DDS; Ins thickness: ins= 0.000000 mm; Room tekst: Installation space; Mtg. above Finished Floor ref Center: CC= 0.27m FFB; Outside dimension: 28.000000; Product: Copper tee 90\X\B0 28/28/28; Model Number: Dra.no: 3; Mtg. Above Slab ref Bottom: Edge= 0.26m SSL; Layer number: 198; Main string number: 00; Angle out: 90; Above Sea Level ref. Center: NN=7.20 m; Project name: OpenBIM; Height: 0; Insulation k-value: 0; Pressure drop: 0; Insulation WSVO: 0; Mtg. Above Slab ref Center: CC= 0.27m SSL; Flow (m\X\B3/h): 0.0 m\X\B3/h; Floor number: Storey: 4; Dimension tee: 25; Dimension out: 25; Dimension in: 25; Width: 25; Medium: Gas middle pressure; Flow (l/h): 0.000000 l/h; Part number: .000; Mtg. Below Ceiling ref Top: Top= 3.02m FCL; Sub string number: .0000; Room number: 02.04; Dimension DN: 25 mm; Product Number: TP-130308-311; Building Part: Building: 0; X: X=8.13; Flow (l/s): 0.00 l/s; Pipe thickness:: x1.5; Abs. pressure: 0.0 Pa; Velocity: 0.00 m/s
AC_Pset_RenovationAndPhasing - Renovation Status: Existing
Name | Y | Length
Tee | Y=12.25 | 0.0 m
Tee | Y=12.88 | 38.0 m

# IfcFlowFitting: TP-130308-312 (2)
In: 01 First floor
Type - Description: Copper tee 90\X\B0 35/22/35; ApplicableOccurrence: Generic; PredefinedType: JUNCTION
Type - Pset_ManufacturerTypeInformation - ArticleNumber: TP-130308-312; ModelReference: Copper tee 90\X\B0 35/22/35; Manufacturer: DDS
Type - Pset_PipeFittingTypeCommon - SubType: Junction Tee; NominalDiameter: 32, 32, 20; InnerDiameter: 32, 32, 20; OuterDiameter: 35, 35, 22
Material: IFC Building Material
Pset_DDS - Rotation: 90.000000; Insulation product text: Fibre plastic covered; Ins thickness: ins= 30.000000 mm; Manufacturer: DDS; Dimension out: 32; Dimension in: 32; Width: 32; Length: 0.1 m; X: X=29.38; Product: Copper tee 90\X\B0 35/22/35; Dimension DN: 32 mm; Model Number: Dra.no: 2; Insulation product number: MK032100; Main string number: 00; Dimension tee: 20; Angle out: 90; Insulation WSVO: 100; Project name: OpenBIM; Height: 0; Insulation k-value: 0; Pressure drop: 0; Flow (m\X\B3/h): 0.0 m\X\B3/h; Floor number: Storey: 3; Flow (l/h): 0.000000 l/h; Part number: .000; Outside dimension: 35.000000; Sub string number: .0000; Product Number: TP-130308-312; Building Part: Building: 0; Mtg. Below Ceiling ref Top: Top= 0.00m FCL; Flow (l/s): 0.00 l/s; Pipe thickness:: x1.5; Abs. pressure: 0.0 Pa; Velocity: 0.00 m/s
AC_Pset_RenovationAndPhasing - Renovation Status: Existing
Name | Mtg. Below Ceiling ref Center | Above Sea Level ref. Bottom | Mtg. Above Slab ref Bottom | Mtg. Above Slab ref Center | Y | Layer number | Mtg. above Finished Floor ref Center | Mounting Height | Above Sea Level ref. Center | Medium
Tee | CC= 3.50m FCL | NNUK=3.07 m | Edge= -0.22m SSL | CC= -0.20m SSL | Y=11.83 | 6 | CC= -0.20m FFB | -0.20 m | NN=3.10 m | Heat return
Tee | CC= 3.40m FCL | NNUK=3.17 m | Edge= -0.12m SSL | CC= -0.10m SSL | Y=11.94 | 5 | CC= -0.10m FFB | -0.10 m | NN=3.20 m | Heat flow

# IfcFlowFitting: TP-130308-314 (2)
In: 00 Ground floor
Type - Description: Copper tee 90\X\B0 35/35/35; ApplicableOccurrence: Generic; PredefinedType: JUNCTION
Type - Pset_ManufacturerTypeInformation - ArticleNumber: TP-130308-314; ModelReference: Copper tee 90\X\B0 35/35/35; Manufacturer: DDS
Type - Pset_PipeFittingTypeCommon - SubType: Junction Cross; NominalDiameter: 20, 20, 32; InnerDiameter: 20, 20, 32; OuterDiameter: 22, 22, 35
Material: IFC Building Material
Pset_DDS - Pipe thickness:: x1.0; Dimension DN: 20 mm; Manufacturer: DDS; Dimension tee: 32; Ins thickness: ins= 0.000000 mm; Product: Copper tee 90\X\B0 35/35/35; Model Number: Dra.no: 1; Width: 20; Main string number: 00; Dimension in: 20; Dimension out: 20; Angle out: 90; Project name: OpenBIM; Height: 0; Insulation k-value: 0; Pressure drop: 0; Insulation WSVO: 0; Outside dimension: 22.000000; Flow (m\X\B3/h): 0.0 m\X\B3/h; Floor number: Storey: 2; Room tekst: Hallway; Flow (l/h): 0.000000 l/h; Part number: .000; Sub string number: .0000; Room number: 00.03; Rotation: 0.000000; Product Number: TP-130308-314; Length: 32.0 m; Building Part: Building: 0; Flow (l/s): 0.00 l/s; Abs. pressure: 0.0 Pa; Velocity: 0.00 m/s
AC_Pset_RenovationAndPhasing - Renovation Status: Existing
Name | Y | Above Sea Level ref. Bottom | Mtg. Below Ceiling ref Center | Medium | Mtg. Above Slab ref Bottom | Mtg. Above Slab ref Center | Above Sea Level ref. Center | Layer number | Mtg. above Finished Floor ref Center | Mounting Height | X | Mtg. Below Ceiling ref Top
Tee | Y=22.09 | NNUK=-0.42 m | CC= 3.50m FCL | Heat flow | Edge= -0.21m SSL | CC= -0.20m SSL | NN=-0.40 m | 5 | CC= -0.20m FFB | -0.20 m | X=28.67 | Top= 3.49m FCL
Tee | Y=21.96 | NNUK=-0.32 m | CC= 3.40m FCL | Heat return | Edge= -0.11m SSL | CC= -0.10m SSL | NN=-0.30 m | 6 | CC= -0.10m FFB | -0.10 m | X=28.57 | Top= 3.39m FCL

# IfcFlowFitting: TP-130308-316 (2)
In: 02 Second floor
Type - Description: Copper tee 90\X\B0 42/35/42; ApplicableOccurrence: Generic; PredefinedType: JUNCTION
Type - Pset_ManufacturerTypeInformation - ArticleNumber: TP-130308-316; ModelReference: Copper tee 90\X\B0 42/35/42; Manufacturer: DDS
Type - Pset_PipeFittingTypeCommon - SubType: Junction Tee; NominalDiameter: 40, 40, 32; InnerDiameter: 39, 39, 32; OuterDiameter: 42, 42, 35
Material: IFC Building Material
Pset_DDS - Dimension DN: 40 mm; Manufacturer: DDS; Insulation product number: ZP150/948; Dimension tee: 32; Ins thickness: ins= 9.000000 mm; Length: 0.1 m; Room tekst: Installation space; Product: Copper tee 90\X\B0 42/35/42; Model Number: Dra.no: 3; Width: 40; Main string number: 00; Dimension in: 40; Dimension out: 40; Angle out: 90; Project name: OpenBIM; Height: 0; Insulation k-value: 0; Pressure drop: 0; Insulation WSVO: 0; Insulation product text: Pipe insulation; Outside dimension: 42.000000; Flow (m\X\B3/h): 0.0 m\X\B3/h; Floor number: Storey: 4; Flow (l/h): 0.000000 l/h; Part number: .000; Sub string number: .0000; Room number: 02.04; Product Number: TP-130308-316; Building Part: Building: 0; Flow (l/s): 0.00 l/s; Pipe thickness:: x1.5; Abs. pressure: 0.0 Pa; Velocity: 0.00 m/s
AC_Pset_RenovationAndPhasing - Renovation Status: Existing
Name | Mounting Height | Mtg. Below Ceiling ref Center | Y | Rotation | Medium | Above Sea Level ref. Bottom | Mtg. above Finished Floor ref Center | X | Above Sea Level ref. Center | Layer number | Mtg. Above Slab ref Center | Mtg. Above Slab ref Bottom | Mtg. Below Ceiling ref Top
Tee | 0.20 m | CC= 3.23m FCL | Y=12.82 | 180.000000 | Heat flow | NNUK=6.96 m | CC= 0.07m FFB | X=8.27 | NN=7.00 m | 5 | CC= 0.07m SSL | Edge= 0.05m SSL | Top= 3.21m FCL
Tee | 0.10 m | CC= 3.33m FCL | Y=12.94 | 270.000000 | Heat return | NNUK=6.86 m | CC= -0.03m FFB | X=8.03 | NN=6.90 m | 6 | CC= -0.03m SSL | Edge= -0.05m SSL | Top= 3.31m FCL

# IfcFlowFitting: TP-130308-318 (2)
In: 02 Second floor
Type - Description: Copper tee 90\X\B0 54/35/54; ApplicableOccurrence: Generic; PredefinedType: JUNCTION
Type - Pset_ManufacturerTypeInformation - ArticleNumber: TP-130308-318; ModelReference: Copper tee 90\X\B0 54/35/54; Manufacturer: DDS
Type - Pset_PipeFittingTypeCommon - SubType: Junction Tee; NominalDiameter: 50, 50, 32; InnerDiameter: 50, 50, 32; OuterDiameter: 54, 54, 35
Material: IFC Building Material
Pset_DDS - Dimension DN: 50 mm; Insulation product text: Pipe insulation; Manufacturer: DDS; Insulation product number: ZP150/949; Dimension tee: 32; Ins thickness: ins= 9.000000 mm; Length: 0.1 m; Room tekst: Installation space; Model Number: Dra.no: 3; Width: 50; Main string number: 00; Dimension out: 50; Dimension in: 50; Angle out: 90; Project name: OpenBIM; Height: 0; Insulation k-value: 0; Pressure drop: 0; Insulation WSVO: 0; Flow (m\X\B3/h): 0.0 m\X\B3/h; Floor number: Storey: 4; Product: Copper tee 90\X\B0 54/35/54; Flow (l/h): 0.000000 l/h; Part number: .000; Sub string number: .0000; Pipe thickness:: x2.0; Outside dimension: 54.000000; Room number: 02.04; Product Number: TP-130308-318; Building Part: Building: 0; Flow (l/s): 0.00 l/s; Abs. pressure: 0.0 Pa; Velocity: 0.00 m/s
AC_Pset_RenovationAndPhasing - Renovation Status: Existing
Name | Mounting Height | Mtg. Below Ceiling ref Center | Rotation | Mtg. Above Slab ref Bottom | Medium | Above Sea Level ref. Bottom | Mtg. above Finished Floor ref Center | X | Above Sea Level ref. Center | Layer number | Mtg. Above Slab ref Center | Mtg. Below Ceiling ref Top | Y
Tee | 0.20 m | CC= 3.23m FCL | 180.000000 | Edge= 0.04m SSL | Heat flow | NNUK=6.95 m | CC= 0.07m FFB | X=8.27 | NN=7.00 m | 5 | CC= 0.07m SSL | Top= 3.21m FCL | Y=13.45
Tee | 0.10 m | CC= 3.33m FCL | 270.000000 | Edge= -0.06m SSL | Heat return | NNUK=6.85 m | CC= -0.03m FFB | X=8.03 | NN=6.90 m | 6 | CC= -0.03m SSL | Top= 3.31m FCL | Y=13.57

# IfcFlowFitting: TP-130308-329 (2)
In: 02 Second floor
Type - Description: Copper tee 90\X\B0 108/108/108; ApplicableOccurrence: Generic; PredefinedType: JUNCTION
Type - Pset_ManufacturerTypeInformation - ArticleNumber: TP-130308-329; ModelReference: Copper tee 90\X\B0 108/108/108; Manufacturer: DDS
Type - Pset_PipeFittingTypeCommon - SubType: Junction Tee; NominalDiameter: 100, 100, 100; InnerDiameter: 103, 103, 103; OuterDiameter: 108, 108, 108
Material: IFC Building Material
Pset_DDS - Rotation: 90.000000; Mounting Height: 1.80 m; Mtg. Below Ceiling ref Center: CC= 1.63m FCL; X: X=8.06; Mtg. Above Slab ref Bottom: Edge= 1.62m SSL; Manufacturer: DDS; Dimension DN: 100 mm; Ins thickness: ins= 9.000000 mm; Above Sea Level ref. Bottom: NNUK=8.50 m; Room tekst: Installation space; Mtg. above Finished Floor ref Center: CC= 1.67m FFB; Medium: Smoke Exhaust; Insulation product text: Pipe insulation; Model Number: Dra.no: 3; Layer number: 16; Main string number: 00; Angle out: 90; Dimension out: 100; Dimension in: 100; Dimension tee: 100; Width: 100; Project name: OpenBIM; Height: 0; Insulation k-value: 0; Pressure drop: 0; Insulation WSVO: 0; Mtg. Above Slab ref Center: CC= 1.67m SSL; Flow (m\X\B3/h): 0.0 m\X\B3/h; Floor number: Storey: 4; Mtg. Below Ceiling ref Top: Top= 1.58m FCL; Outside dimension: 108.000000; Flow (l/h): 0.000000 l/h; Part number: .000; Sub string number: .0000; Product: Copper tee 90\X\B0 108/108/108; Room number: 02.04; Insulation product number: ZP150/952; Above Sea Level ref. Center: NN=8.60 m; Building Part: Building: 0; Flow (l/s): 0.00 l/s; Abs. pressure: 0.0 Pa; Velocity: 0.00 m/s; Product Number: TP-130308-329; Pipe thickness:: x2.5
AC_Pset_RenovationAndPhasing - Renovation Status: Existing
Name | Length | Y
Tee | 246.0 m | Y=13.51
Tee | 0.1 m | Y=12.88

# IfcFlowFitting: TP2000.BIM (22)
In: 00 Ground floor
Type - PredefinedType: JUNCTION
Type - Pset_PipeFittingTypeCommon - SubType: Junction Tee; NominalDiameter: 32, 32, 15; InnerDiameter: 32, 32, 16; OuterDiameter: 35, 35, 18
Material: IFC Building Material
Pset_DDS - Dimension out: 32; Dimension in: 32; Width: 32; Ins thickness: ins= 0.000000 mm; Length: 0.0 m; Product: No product matches criteria; Dimension DN: 32 mm; Model Number: Dra.no: 1; Main string number: 00; Angle out: 90; Project name: OpenBIM; Height: 0; Insulation k-value: 0; Pressure drop: 0; Insulation WSVO: 0; Flow (m\X\B3/h): 0.0 m\X\B3/h; Floor number: Storey: 2; Dimension tee: 15; Flow (l/h): 0.000000 l/h; Part number: .000; Outside dimension: 35.000000; Sub string number: .0000; Rotation: 0.000000; Product Number: TP-130308-314; Building Part: Building: 0; Flow (l/s): 0.00 l/s; Pipe thickness:: x1.5; Abs. pressure: 0.0 Pa; Velocity: 0.00 m/s
AC_Pset_RenovationAndPhasing - Renovation Status: Existing
Name | Mtg. Above Slab ref Center | Y | Mounting Height | X | Mtg. Below Ceiling ref Center | Mtg. Below Ceiling ref Top | Above Sea Level ref. Center | Room tekst | Layer number | Mtg. Above Slab ref Bottom | Room number | Above Sea Level ref. Bottom | Mtg. above Finished Floor ref Center | Medium
Tee | CC= -0.10m SSL | Y=21.96 | -0.10 m | X=14.07 | CC= 3.40m FCL | Top= 3.38m FCL | NN=-0.30 m | Office | 6 | Edge= -0.12m SSL | 00.21 | NNUK=-0.33 m | CC= -0.10m FFB | Heat return
Tee | CC= -0.10m SSL | Y=21.96 | -0.10 m | X=16.32 | CC= 3.40m FCL | Top= 3.38m FCL | NN=-0.30 m | Office | 6 | Edge= -0.12m SSL | 00.21 | NNUK=-0.33 m | CC= -0.10m FFB | Heat return
Tee | CC= -0.10m SSL | Y=21.96 | -0.10 m | X=18.57 | CC= 3.40m FCL | Top= 3.38m FCL | NN=-0.30 m | Office | 6 | Edge= -0.12m SSL | 001 | NNUK=-0.33 m | CC= -0.10m FFB | Heat return
Tee | CC= -0.10m SSL | Y=21.96 | -0.10 m | X=11.82 | CC= 3.40m FCL | Top= 3.38m FCL | NN=-0.30 m | Office | 6 | Edge= -0.12m SSL | 00.20 | NNUK=-0.33 m | CC= -0.10m FFB | Heat return
Tee | CC= -0.10m SSL | Y=21.96 | -0.10 m | X=9.57 | CC= 3.40m FCL | Top= 3.38m FCL | NN=-0.30 m | Office | 6 | Edge= -0.12m SSL | 00.20 | NNUK=-0.33 m | CC= -0.10m FFB | Heat return
Tee | CC= -0.10m SSL | Y=21.96 | -0.10 m | X=20.82 | CC= 3.40m FCL | Top= 3.38m FCL | NN=-0.30 m | Office | 6 | Edge= -0.12m SSL | 001 | NNUK=-0.33 m | CC= -0.10m FFB | Heat return
Tee | CC= -0.10m SSL | Y=21.96 | -0.10 m | X=7.32 | CC= 3.40m FCL | Top= 3.38m FCL | NN=-0.30 m | Staircase | 6 | Edge= -0.12m SSL | 00.05 | NNUK=-0.33 m | CC= -0.10m FFB | Heat return
Tee | CC= -0.10m SSL | Y=21.96 | -0.10 m | X=23.07 | CC= 3.40m FCL | Top= 3.38m FCL | NN=-0.30 m | Storage | 6 | Edge= -0.12m SSL | 00.22 | NNUK=-0.33 m | CC= -0.10m FFB | Heat return
Tee | CC= -0.10m SSL | Y=21.96 | -0.10 m | X=25.37 | CC= 3.40m FCL | Top= 3.38m FCL | NN=-0.30 m | Hallway | 6 | Edge= -0.12m SSL | 00.03 | NNUK=-0.33 m | CC= -0.10m FFB | Heat return
Tee | CC= -0.10m SSL | Y=21.96 | -0.10 m | X=27.62 | CC= 3.40m FCL | Top= 3.38m FCL | NN=-0.30 m | Hallway | 6 | Edge= -0.12m SSL | 00.03 | NNUK=-0.33 m | CC= -0.10m FFB | Heat return
Tee | CC= -0.10m SSL | Y=21.47 | -0.10 m | X=5.60 | CC= 3.40m FCL | Top= 3.38m FCL | NN=-0.30 m | Staircase | 6 | Edge= -0.12m SSL | 00.05 | NNUK=-0.33 m | CC= -0.10m FFB | Heat return
Tee | CC= -0.20m SSL | Y=22.09 | -0.20 m | X=27.57 | CC= 3.50m FCL | Top= 3.48m FCL | NN=-0.40 m | Hallway | 5 | Edge= -0.22m SSL | 00.03 | NNUK=-0.43 m | CC= -0.20m FFB | Heat flow
Tee | CC= -0.20m SSL | Y=22.09 | -0.20 m | X=25.32 | CC= 3.50m FCL | Top= 3.48m FCL | NN=-0.40 m | Hallway | 5 | Edge= -0.22m SSL | 00.03 | NNUK=-0.43 m | CC= -0.20m FFB | Heat flow
Tee | CC= -0.20m SSL | Y=22.09 | -0.20 m | X=23.02 | CC= 3.50m FCL | Top= 3.48m FCL | NN=-0.40 m | Storage | 5 | Edge= -0.22m SSL | 00.22 | NNUK=-0.43 m | CC= -0.20m FFB | Heat flow
Tee | CC= -0.20m SSL | Y=22.09 | -0.20 m | X=20.77 | CC= 3.50m FCL | Top= 3.48m FCL | NN=-0.40 m | Office | 5 | Edge= -0.22m SSL | 001 | NNUK=-0.43 m | CC= -0.20m FFB | Heat flow
Tee | CC= -0.20m SSL | Y=22.09 | -0.20 m | X=18.52 | CC= 3.50m FCL | Top= 3.48m FCL | NN=-0.40 m | Office | 5 | Edge= -0.22m SSL | 001 | NNUK=-0.43 m | CC= -0.20m FFB | Heat flow
Tee | CC= -0.20m SSL | Y=22.09 | -0.20 m | X=16.27 | CC= 3.50m FCL | Top= 3.48m FCL | NN=-0.40 m | Office | 5 | Edge= -0.22m SSL | 00.21 | NNUK=-0.43 m | CC= -0.20m FFB | Heat flow
Tee | CC= -0.20m SSL | Y=22.09 | -0.20 m | X=14.02 | CC= 3.50m FCL | Top= 3.48m FCL | NN=-0.40 m | Office | 5 | Edge= -0.22m SSL | 00.21 | NNUK=-0.43 m | CC= -0.20m FFB | Heat flow
Tee | CC= -0.20m SSL | Y=22.09 | -0.20 m | X=11.77 | CC= 3.50m FCL | Top= 3.48m FCL | NN=-0.40 m | Office | 5 | Edge= -0.22m SSL | 00.20 | NNUK=-0.43 m | CC= -0.20m FFB | Heat flow
