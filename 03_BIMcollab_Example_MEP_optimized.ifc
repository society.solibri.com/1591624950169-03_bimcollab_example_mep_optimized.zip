Properties of the parts of a building model (IFC2X3), part 13 of 14

# IfcFlowSegment: SS091209008 (4)
Type - Pset_ManufacturerTypeInformation - ArticleNumber: SS091209008; ModelReference: Copper pipes length 5 m 42x1,5 mm; Manufacturer: DDS
Type - Pset_PipeSegmentTypeCommon - NominalDiameter: 40; InnerDiameter: 39; OuterDiameter: 42
Material: ML-Copper pipes length 5 m 42x1,5 mm-Pipe insulation 9x48 mm gray insulation thickness 9 mm-9
Pset_DDS - Pressure drop: 0 Pa; Drain slope: 1:0; Manufacturer: DDS; Insulation product number: ZP150/948; Ins thickness: ins= 9.000000 mm; Room tekst: Installation space; Product: Copper pipes length 5 m 42x1,5 mm; Model Number: Dra.no: 3; Drain slope (%): 10000.0 %; Dimension DN: 40; Main string number: 00; Width: 40; Project name: OpenBIM; Insulation WSVO: 0; Insulation k-value: 0; Insulation product text: Pipe insulation; Outside dimension: 42.000000; Floor number: Storey: 4; Drain Qww: Qww=0.00 l/s; Flow (l/h): 0.000000 l/h; Part number: .000; Sub string number: .0000; Drain slope (\X\B0): 90.0\X\B0; Temperature: 0.00 \X\B0C; Drain DU: DU=0.00 l/s; Room number: 02.04; Product Number: SS091209008; Building Part: Building: 0; Peak flow (l/s): 0.00 l/s; Flow (l/s): 0.00 l/s; Flowsegment thickness: x1.5; Abs. pressure: 0.0 Pa; Velocity: 0.00 m/s
AC_Pset_RenovationAndPhasing - Renovation Status: Existing
Name | Pset_FlowSegmentPipeSegment, Length (mm) | Mounting Height | Mtg. Below Ceiling ref Center | Y | Mtg. Above Slab ref Bottom | Medium | Above Sea Level ref. Bottom | Mtg. above Finished Floor ref Center | X | Above Sea Level ref. Center | Layer number | Pset_DDS, Length | Mtg. Above Slab ref Center | Mtg. Below Ceiling ref Top
Pipe | 28.149 | 0.20 m | CC= 3.23m FCL | Y=12.76 | Edge= 0.04m SSL | Heat flow | NNUK=6.97 m | CC= 0.07m FFB | X=8.27 | NN=7.00 m | 5 | 0 | CC= 0.07m SSL | Top= 3.20m FCL
Pipe | 513.519 | 0.20 m | CC= 3.23m FCL | Y=12.85 | Edge= 0.04m SSL | Heat flow | NNUK=6.97 m | CC= 0.07m FFB | X=8.27 | NN=7.00 m | 5 | 1 | CC= 0.07m SSL | Top= 3.20m FCL
Pipe | 51.5264 | 0.10 m | CC= 3.33m FCL | Y=12.86 | Edge= -0.06m SSL | Heat return | NNUK=6.87 m | CC= -0.03m FFB | X=8.03 | NN=6.90 m | 6 | 0 | CC= -0.03m SSL | Top= 3.30m FCL
Pipe | 503.43 | 0.10 m | CC= 3.33m FCL | Y=12.97 | Edge= -0.06m SSL | Heat return | NNUK=6.87 m | CC= -0.03m FFB | X=8.03 | NN=6.90 m | 6 | 1 | CC= -0.03m SSL | Top= 3.30m FCL

# IfcFlowSegment: SS091209009 (12)
In: 02 Second floor
Type - Description: Copper pipes length 5 m 54x2 mm; ApplicableOccurrence: Copper; PredefinedType: RIGIDSEGMENT
Type - Pset_ManufacturerTypeInformation - ArticleNumber: SS091209009; ModelReference: Copper pipes length 5 m 54x2 mm; Manufacturer: DDS
Type - Pset_PipeSegmentTypeCommon - NominalDiameter: 50; InnerDiameter: 50; OuterDiameter: 54
Material: ML-Copper pipes length 5 m 54x2 mm-Pipe insulation 9x54 mm gray insulation thickness 9 mm-9
Pset_DDS - Pressure drop: 0 Pa; Drain slope: 1:0; Insulation product text: Pipe insulation; Manufacturer: DDS; Insulation product number: ZP150/949; Ins thickness: ins= 9.000000 mm; Room tekst: Installation space; Model Number: Dra.no: 3; Drain slope (%): 10000.0 %; Main string number: 00; Width: 50; Dimension DN: 50; Project name: OpenBIM; Insulation WSVO: 0; Insulation k-value: 0; Floor number: Storey: 4; Drain Qww: Qww=0.00 l/s; Flow (l/h): 0.000000 l/h; Part number: .000; Sub string number: .0000; Drain slope (\X\B0): 90.0\X\B0; Temperature: 0.00 \X\B0C; Drain DU: DU=0.00 l/s; Flowsegment thickness: x2.0; Product: Copper pipes length 5 m 54x2 mm; Outside dimension: 54.000000; Room number: 02.04; Product Number: SS091209009; Building Part: Building: 0; Peak flow (l/s): 0.00 l/s; Flow (l/s): 0.00 l/s; Abs. pressure: 0.0 Pa; Velocity: 0.00 m/s
AC_Pset_RenovationAndPhasing - Renovation Status: Existing
Name | Mounting Height | Mtg. Below Ceiling ref Center | Mtg. Above Slab ref Bottom | Medium | Above Sea Level ref. Bottom | Y | Mtg. above Finished Floor ref Center | X | Above Sea Level ref. Center | Layer number | Pset_DDS, Length | Mtg. Above Slab ref Center | Mtg. Below Ceiling ref Top | Pset_FlowSegmentPipeSegment, Length (mm)
Pipe | 0.20 m | CC= 3.23m FCL | Edge= 0.04m SSL | Heat flow | NNUK=6.97 m | Y=13.38 | CC= 0.07m FFB | X=8.27 | NN=7.00 m | 5 | 0 | CC= 0.07m SSL | Top= 3.20m FCL | 31.0754
Pipe | 0.20 m | CC= 3.23m FCL | Edge= 0.04m SSL | Heat flow | NNUK=6.97 m | Y=13.48 | CC= 0.07m FFB | X=8.27 | NN=7.00 m | 5 | 1 | CC= 0.07m SSL | Top= 3.20m FCL | 779.014
Pipe | 0.28 m | CC= 3.16m FCL | Edge= 0.11m SSL | Heat flow | NNUK=7.04 m | Y=14.34 | CC= 0.15m FFB | X=8.27 | NN=7.08 m | 5 | 2 | CC= 0.15m SSL | Top= 3.12m FCL | 2050
Pipe | 2.40 m | CC= 1.03m FCL | Edge= 2.24m SSL | Heat flow | NNUK=9.17 m | Y=14.41 | CC= 2.27m FFB | X=8.27 | NN=9.20 m | 5 | 0 | CC= 2.27m SSL | Top= 1.00m FCL | 108.195
Pipe | 2.32 m | CC= 1.11m FCL | Edge= 2.16m SSL | Heat flow | NNUK=9.09 m | Y=14.59 | CC= 2.19m FFB | X=8.27 | NN=9.13 m | 5 | 0 | CC= 2.19m SSL | Top= 1.07m FCL | 425
Pipe | 0.10 m | CC= 3.33m FCL | Edge= -0.06m SSL | Heat return | NNUK=6.87 m | Y=13.60 | CC= -0.03m FFB | X=8.03 | NN=6.90 m | 6 | 0 | CC= -0.03m SSL | Top= 3.30m FCL | 483.151
Pipe | 0.10 m | CC= 3.33m FCL | Edge= -0.06m SSL | Heat return | NNUK=6.87 m | Y=14.12 | CC= -0.03m FFB | X=8.04 | NN=6.90 m | 6 | 0 | CC= -0.03m SSL | Top= 3.30m FCL | 141.213
Pipe | 0.10 m | CC= 3.33m FCL | Edge= -0.06m SSL | Heat return | NNUK=6.87 m | Y=14.28 | CC= -0.03m FFB | X=8.12 | NN=6.90 m | 6 | -0 | CC= -0.03m SSL | Top= 3.30m FCL | 20.8629
Pipe | 0.17 m | CC= 3.26m FCL | Edge= 0.01m SSL | Heat return | NNUK=6.94 m | Y=14.34 | CC= 0.04m FFB | X=8.12 | NN=6.98 m | 6 | 2 | CC= 0.04m SSL | Top= 3.22m FCL | 2150
Pipe | 2.40 m | CC= 1.03m FCL | Edge= 2.24m SSL | Heat return | NNUK=9.17 m | Y=14.41 | CC= 2.27m FFB | X=8.12 | NN=9.20 m | 6 | 0 | CC= 2.27m SSL | Top= 1.00m FCL | 233.492
Pipe | 2.32 m | CC= 1.11m FCL | Edge= 2.16m SSL | Heat return | NNUK=9.09 m | Y=14.72 | CC= 2.19m FFB | X=8.12 | NN=9.13 m | 6 | 0 | CC= 2.19m SSL | Top= 1.07m FCL | 425
Pipe | 0.10 m | CC= 3.33m FCL | Edge= -0.06m SSL | Heat return | NNUK=6.87 m | Y=13.49 | CC= -0.03m FFB | X=8.03 | NN=6.90 m | 6 | 0 | CC= -0.03m SSL | Top= 3.30m FCL | 41

# IfcFlowSegment: SS091209013 (8)
Type - Description: Copper pipes length 5 m 108x2,5 mm; ApplicableOccurrence: Copper; PredefinedType: RIGIDSEGMENT
Type - Pset_ManufacturerTypeInformation - ArticleNumber: SS091209013; ModelReference: Copper pipes length 5 m 108x2,5 mm; Manufacturer: DDS
Type - Pset_PipeSegmentTypeCommon - NominalDiameter: 100; InnerDiameter: 103; OuterDiameter: 108
Material: ML-Copper pipes length 5 m 108x2,5 mm-Pipe insulation 9x108 mm gray insulation thickness 9 mm-9
Pset_DDS - Pressure drop: 0 Pa; X: X=8.06; Drain slope: 1:0; Manufacturer: DDS; Product Number: SS091209013; Ins thickness: ins= 9.000000 mm; Medium: Smoke Exhaust; Insulation product text: Pipe insulation; Product: Copper pipes length 5 m 108x2,5 mm; Layer number: 16; Drain slope (%): 10000.0 %; Main string number: 00; Width: 100; Dimension DN: 100; Project name: OpenBIM; Insulation WSVO: 0; Insulation k-value: 0; Drain Qww: Qww=0.00 l/s; Outside dimension: 108.000000; Flow (l/h): 0.000000 l/h; Part number: .000; Sub string number: .0000; Drain slope (\X\B0): 90.0\X\B0; Temperature: 0.00 \X\B0C; Drain DU: DU=0.00 l/s; Insulation product number: ZP150/952; Building Part: Building: 0; Peak flow (l/s): 0.00 l/s; Flow (l/s): 0.00 l/s; Abs. pressure: 0.0 Pa; Velocity: 0.00 m/s; Flowsegment thickness: x2.5
AC_Pset_RenovationAndPhasing - Renovation Status: Existing
Name | In | Mounting Height | Mtg. Below Ceiling ref Center | Room tekst | Mtg. Above Slab ref Bottom | Mtg. above Finished Floor ref Center | Above Sea Level ref. Center | Y | Model Number | Above Sea Level ref. Bottom | Mtg. Below Ceiling ref Top | Pset_DDS, Length | Mtg. Above Slab ref Center | Floor number | Room number | Pset_FlowSegmentPipeSegment, Length (mm)
Pipe | 02 Second floor | 1.50 m | CC= 1.93m FCL | Installation space | Edge= 1.31m SSL | CC= 1.37m FFB | NN=8.30 m | Y=13.51 | Dra.no: 3 | NNUK=8.24 m | Top= 1.87m FCL | 0 | CC= 1.37m SSL | Storey: 4 | 02.04 | 176.613
Pipe | 02 Second floor | 1.50 m | CC= 1.93m FCL | Installation space | Edge= 1.31m SSL | CC= 1.37m FFB | NN=8.30 m | Y=12.88 | Dra.no: 3 | NNUK=8.24 m | Top= 1.87m FCL | 0 | CC= 1.37m SSL | Storey: 4 | 02.04 | 176.613
Pipe | 02 Second floor | 1.95 m | CC= 1.48m FCL | Installation space | Edge= 1.76m SSL | CC= 1.82m FFB | NN=8.75 m | Y=14.12 | Dra.no: 3 | NNUK=8.69 m | Top= 1.42m FCL | 1 | CC= 1.82m SSL | Storey: 4 | 02.04 | 1300
Pipe | 02 Second floor | 1.80 m | CC= 1.63m FCL | Installation space | Edge= 1.61m SSL | CC= 1.67m FFB | NN=8.60 m | Y=13.63 | Dra.no: 3 | NNUK=8.54 m | Top= 1.57m FCL | 0 | CC= 1.67m SSL | Storey: 4 | 02.04 | 343.182
Pipe | 02 Second floor | 1.80 m | CC= 1.63m FCL | Installation space | Edge= 1.61m SSL | CC= 1.67m FFB | NN=8.60 m | Y=13.00 | Dra.no: 3 | NNUK=8.54 m | Top= 1.57m FCL | 0 | CC= 1.67m SSL | Storey: 4 | 02.04 | 384.029
Pipe | 02 Second floor | 1.80 m | CC= 1.63m FCL | Installation space | Edge= 1.61m SSL | CC= 1.67m FFB | NN=8.60 m | Y=12.40 | Dra.no: 3 | NNUK=8.54 m | Top= 1.57m FCL | 0 | CC= 1.67m SSL | Storey: 4 | 02.04 | 357.03
Pipe | 02 Second floor | 1.50 m | CC= 1.93m FCL | Installation space | Edge= 1.31m SSL | CC= 1.37m FFB | NN=8.30 m | Y=12.25 | Dra.no: 3 | NNUK=8.24 m | Top= 1.87m FCL | 0 | CC= 1.37m SSL | Storey: 4 | 02.04 | 149.693
Pipe | 03. Roof | -0.25 m | CC= 3.62m FCL |  | Edge= -0.31m SSL | CC= -0.25m FFB | NN=10.05 m | Y=14.12 | Dra.no: 4 | NNUK=9.99 m | Top= 0.00m FCL | 0 | CC= -0.25m SSL | Storey: 5 |  | 99.9919

# IfcFlowSegment: SS8305160 (59)
Type - Description: Flexible Circular Duct DIN 24146 d 160; ApplicableOccurrence: Circ; PredefinedType: FLEXIBLESEGMENT
Type - Pset_ManufacturerTypeInformation - ArticleNumber: SS8305160; ModelReference: Flexible Circular Duct DIN 24146 d 160; Manufacturer: DDS
Type - Pset_DuctSegmentTypeCommon - NominalDiameterOrWidth: 160
Material: ML-Flexible Circular Duct DIN 24146 d 160; Group: Supply air
Pset_DDS - Dimension DN: 160 mm; Product: Flexible Circular Duct DIN 24146 d 160; Product Number: SS8305160; Manufacturer: DDS; System Name: Supply Air; Layer number: 10; Project name: OpenBIM; Width: 160; Building Part: Building: 0
AC_Pset_RenovationAndPhasing - Renovation Status: Existing
Name | In | Mounting Height | Above Sea Level ref. Center | Mtg. Below Ceiling ref Center | Velocity | Y | Mtg. Above Slab ref Bottom | Main string number | Mtg. above Finished Floor ref Center | Mtg. Above Slab ref Center | Flow | Iso thickness | Mtg. Below Ceiling ref Top | Part number | Medium | Room tekst | Model Number | Room number | Height = Insulation WSVO = Insulation k-value | Pset_DDS, Length | Abs. pressure | Floor number | Above Sea Level ref. Bottom | Flowsegment thickness | Sub string number | X | Pset_FlowSegmentDuctSegment, Length (mm)
01.0006.01 | 00 Ground floor | 3.00 m | NN=2.80 m | CC= 0.30m FCL | 2.76 m/s | Y=18.43 | Edge= 2.92m SSL | 01 | CC= 3.00m FFB | CC= 3.00m SSL | 200.0 m\X\B3/h | iso= 0.000000 mm | Top= 0.22m FCL | .001 | Supply Air | Office | Dra.no: 1 | 00.20 | 0 | 0 | 106.5 Pa | Storey: 2 | NNUK=2.72 m | x0.0 | .0006 | X=9.53 | 62.7547
01.0006.03 | 00 Ground floor | 2.99 m | NN=2.79 m | CC= 0.31m FCL | 2.76 m/s | Y=18.59 | Edge= 2.92m SSL | 01 | CC= 2.99m FFB | CC= 2.99m SSL | 200.0 m\X\B3/h | iso= 0.000000 mm | Top= 0.24m FCL | .003 | Supply Air | Office | Dra.no: 1 | 00.20 | 0 | 1 | 106.5 Pa | Storey: 2 | NNUK=2.72 m | x0.0 | .0006 | X=9.53 | 940.06
01.0006.05 | 00 Ground floor | 2.85 m | NN=2.65 m | CC= 0.45m FCL | 2.76 m/s | Y=19.62 | Edge= 2.77m SSL | 01 | CC= 2.85m FFB | CC= 2.85m SSL | 200.0 m\X\B3/h | iso= 0.000000 mm | Top= 0.37m FCL | .005 | Supply Air | Office | Dra.no: 1 | 00.20 | 0 | 0 | 106.5 Pa | Storey: 2 | NNUK=2.57 m | x0.0 | .0006 | X=9.53 | 28.4367
01.0007.01 | 00 Ground floor | 3.00 m | NN=2.80 m | CC= 0.30m FCL | 2.76 m/s | Y=18.43 | Edge= 2.92m SSL | 01 | CC= 3.00m FFB | CC= 3.00m SSL | 200.0 m\X\B3/h | iso= 0.000000 mm | Top= 0.22m FCL | .001 | Supply Air | Office | Dra.no: 1 | 00.20 | 0 | 0 | 105.7 Pa | Storey: 2 | NNUK=2.72 m | x0.0 | .0007 | X=10.78 | 62.7547
01.0007.03 | 00 Ground floor | 2.99 m | NN=2.79 m | CC= 0.31m FCL | 2.76 m/s | Y=18.59 | Edge= 2.92m SSL | 01 | CC= 2.99m FFB | CC= 2.99m SSL | 200.0 m\X\B3/h | iso= 0.000000 mm | Top= 0.24m FCL | .003 | Supply Air | Office | Dra.no: 1 | 00.20 | 0 | 1 | 105.7 Pa | Storey: 2 | NNUK=2.72 m | x0.0 | .0007 | X=10.78 | 940.06
01.0007.05 | 00 Ground floor | 2.85 m | NN=2.65 m | CC= 0.45m FCL | 2.76 m/s | Y=19.62 | Edge= 2.77m SSL | 01 | CC= 2.85m FFB | CC= 2.85m SSL | 200.0 m\X\B3/h | iso= 0.000000 mm | Top= 0.37m FCL | .005 | Supply Air | Office | Dra.no: 1 | 00.20 | 0 | 0 | 105.7 Pa | Storey: 2 | NNUK=2.57 m | x0.0 | .0007 | X=10.78 | 28.4367
01.0008.01 | 00 Ground floor | 3.00 m | NN=2.80 m | CC= 0.30m FCL | 2.76 m/s | Y=18.43 | Edge= 2.92m SSL | 01 | CC= 3.00m FFB | CC= 3.00m SSL | 200.0 m\X\B3/h | iso= 0.000000 mm | Top= 0.22m FCL | .001 | Supply Air | Office | Dra.no: 1 | 00.21 | 0 | 0 | 105.0 Pa | Storey: 2 | NNUK=2.72 m | x0.0 | .0008 | X=13.69 | 62.7547
01.0008.03 | 00 Ground floor | 2.99 m | NN=2.79 m | CC= 0.31m FCL | 2.76 m/s | Y=18.59 | Edge= 2.92m SSL | 01 | CC= 2.99m FFB | CC= 2.99m SSL | 200.0 m\X\B3/h | iso= 0.000000 mm | Top= 0.24m FCL | .003 | Supply Air | Office | Dra.no: 1 | 00.21 | 0 | 1 | 105.0 Pa | Storey: 2 | NNUK=2.72 m | x0.0 | .0008 | X=13.69 | 940.06
01.0008.05 | 00 Ground floor | 2.85 m | NN=2.65 m | CC= 0.45m FCL | 2.76 m/s | Y=19.62 | Edge= 2.77m SSL | 01 | CC= 2.85m FFB | CC= 2.85m SSL | 200.0 m\X\B3/h | iso= 0.000000 mm | Top= 0.37m FCL | .005 | Supply Air | Office | Dra.no: 1 | 00.21 | 0 | 0 | 105.0 Pa | Storey: 2 | NNUK=2.57 m | x0.0 | .0008 | X=13.69 | 28.4367
01.0009.01 | 00 Ground floor | 3.00 m | NN=2.80 m | CC= 0.30m FCL | 2.76 m/s | Y=18.43 | Edge= 2.92m SSL | 01 | CC= 3.00m FFB | CC= 3.00m SSL | 200.0 m\X\B3/h | iso= 0.000000 mm | Top= 0.22m FCL | .001 | Supply Air | Office | Dra.no: 1 | 00.21 | 0 | 0 | 103.9 Pa | Storey: 2 | NNUK=2.72 m | x0.0 | .0009 | X=15.56 | 62.7547
01.0009.03 | 00 Ground floor | 2.99 m | NN=2.79 m | CC= 0.31m FCL | 2.76 m/s | Y=18.59 | Edge= 2.92m SSL | 01 | CC= 2.99m FFB | CC= 2.99m SSL | 200.0 m\X\B3/h | iso= 0.000000 mm | Top= 0.24m FCL | .003 | Supply Air | Office | Dra.no: 1 | 00.21 | 0 | 1 | 103.9 Pa | Storey: 2 | NNUK=2.72 m | x0.0 | .0009 | X=15.56 | 940.06
01.0009.05 | 00 Ground floor | 2.85 m | NN=2.65 m | CC= 0.45m FCL | 2.76 m/s | Y=19.62 | Edge= 2.77m SSL | 01 | CC= 2.85m FFB | CC= 2.85m SSL | 200.0 m\X\B3/h | iso= 0.000000 mm | Top= 0.37m FCL | .005 | Supply Air | Office | Dra.no: 1 | 00.21 | 0 | 0 | 103.9 Pa | Storey: 2 | NNUK=2.57 m | x0.0 | .0009 | X=15.56 | 28.4367
01.0010.01 | 00 Ground floor | 3.00 m | NN=2.80 m | CC= 0.30m FCL | 2.76 m/s | Y=18.43 | Edge= 2.92m SSL | 01 | CC= 3.00m FFB | CC= 3.00m SSL | 200.0 m\X\B3/h | iso= 0.000000 mm | Top= 0.22m FCL | .001 | Supply Air | Office | Dra.no: 1 | 001 | 0 | 0 | 102.8 Pa | Storey: 2 | NNUK=2.72 m | x0.0 | .0010 | X=18.19 | 62.7547
01.0010.03 | 00 Ground floor | 2.99 m | NN=2.79 m | CC= 0.31m FCL | 2.76 m/s | Y=18.59 | Edge= 2.92m SSL | 01 | CC= 2.99m FFB | CC= 2.99m SSL | 200.0 m\X\B3/h | iso= 0.000000 mm | Top= 0.24m FCL | .003 | Supply Air | Office | Dra.no: 1 | 001 | 0 | 1 | 102.8 Pa | Storey: 2 | NNUK=2.72 m | x0.0 | .0010 | X=18.19 | 940.06
01.0010.05 | 00 Ground floor | 2.85 m | NN=2.65 m | CC= 0.45m FCL | 2.76 m/s | Y=19.62 | Edge= 2.77m SSL | 01 | CC= 2.85m FFB | CC= 2.85m SSL | 200.0 m\X\B3/h | iso= 0.000000 mm | Top= 0.37m FCL | .005 | Supply Air | Office | Dra.no: 1 | 001 | 0 | 0 | 102.8 Pa | Storey: 2 | NNUK=2.57 m | x0.0 | .0010 | X=18.19 | 28.4367
01.0012.01 | 00 Ground floor | 3.00 m | NN=2.80 m | CC= 0.30m FCL | 2.76 m/s | Y=13.58 | Edge= 2.92m SSL | 01 | CC= 3.00m FFB | CC= 3.00m SSL | 200.0 m\X\B3/h | iso= 0.000000 mm | Top= 0.22m FCL | .001 | Supply Air | Office | Dra.no: 1 | 00.19 | 0 | 0 | 57.1 Pa | Storey: 2 | NNUK=2.72 m | x0.0 | .0012 | X=6.75 | 5.25353
01.0012.03 | 00 Ground floor | 2.99 m | NN=2.79 m | CC= 0.31m FCL | 2.76 m/s | Y=13.46 | Edge= 2.92m SSL | 01 | CC= 2.99m FFB | CC= 2.99m SSL | 200.0 m\X\B3/h | iso= 0.000000 mm | Top= 0.25m FCL | .003 | Supply Air | Office | Dra.no: 1 | 00.19 | 0 | 1 | 57.1 Pa | Storey: 2 | NNUK=2.72 m | x0.0 | .0012 | X=6.75 | 703.12
01.0012.05 | 00 Ground floor | 2.80 m | NN=2.60 m | CC= 0.50m FCL | 2.76 m/s | Y=12.66 | Edge= 2.72m SSL | 01 | CC= 2.80m FFB | CC= 2.80m SSL | 200.0 m\X\B3/h | iso= 0.000000 mm | Top= 0.42m FCL | .005 | Supply Air | Office | Dra.no: 1 | 00.19 | 0 | 0 | 57.1 Pa | Storey: 2 | NNUK=2.52 m | x0.0 | .0012 | X=6.75 | 20.2535
01.0013.01 | 00 Ground floor | 3.00 m | NN=2.80 m | CC= 0.30m FCL | 2.76 m/s | Y=13.58 | Edge= 2.92m SSL | 01 | CC= 3.00m FFB | CC= 3.00m SSL | 200.0 m\X\B3/h | iso= 0.000000 mm | Top= 0.22m FCL | .001 | Supply Air | Office | Dra.no: 1 | 00.19 | 0 | 0 | 55.7 Pa | Storey: 2 | NNUK=2.72 m | x0.0 | .0013 | X=8.63 | 5.25353
01.0013.03 | 00 Ground floor | 2.99 m | NN=2.79 m | CC= 0.31m FCL | 2.76 m/s | Y=13.46 | Edge= 2.92m SSL | 01 | CC= 2.99m FFB | CC= 2.99m SSL | 200.0 m\X\B3/h | iso= 0.000000 mm | Top= 0.25m FCL | .003 | Supply Air | Office | Dra.no: 1 | 00.19 | 0 | 1 | 55.7 Pa | Storey: 2 | NNUK=2.72 m | x0.0 | .0013 | X=8.63 | 703.12
01.0013.05 | 00 Ground floor | 2.80 m | NN=2.60 m | CC= 0.50m FCL | 2.76 m/s | Y=12.66 | Edge= 2.72m SSL | 01 | CC= 2.80m FFB | CC= 2.80m SSL | 200.0 m\X\B3/h | iso= 0.000000 mm | Top= 0.42m FCL | .005 | Supply Air | Office | Dra.no: 1 | 00.19 | 0 | 0 | 55.7 Pa | Storey: 2 | NNUK=2.52 m | x0.0 | .0013 | X=8.63 | 20.2535
01.0014.01 | 00 Ground floor | 3.00 m | NN=2.80 m | CC= 0.30m FCL | 2.76 m/s | Y=14.36 | Edge= 2.92m SSL | 01 | CC= 3.00m FFB | CC= 3.00m SSL | 200.0 m\X\B3/h | iso= 0.000000 mm | Top= 0.22m FCL | .001 | Supply Air | Office | Dra.no: 1 | 00.17 | 0 | 0 | 57.7 Pa | Storey: 2 | NNUK=2.72 m | x0.0 | .0014 | X=13.75 | 6.56101
01.0014.03 | 00 Ground floor | 2.99 m | NN=2.79 m | CC= 0.31m FCL | 2.76 m/s | Y=14.24 | Edge= 2.92m SSL | 01 | CC= 2.99m FFB | CC= 2.99m SSL | 200.0 m\X\B3/h | iso= 0.000000 mm | Top= 0.25m FCL | .003 | Supply Air | Office | Dra.no: 1 | 00.17 | 0 | 1 | 57.7 Pa | Storey: 2 | NNUK=2.72 m | x0.0 | .0014 | X=13.75 | 762.373
01.0014.05 | 00 Ground floor | 2.80 m | NN=2.60 m | CC= 0.50m FCL | 2.76 m/s | Y=13.38 | Edge= 2.72m SSL | 01 | CC= 2.80m FFB | CC= 2.80m SSL | 200.0 m\X\B3/h | iso= 0.000000 mm | Top= 0.42m FCL | .005 | Supply Air | Office | Dra.no: 1 | 00.17 | 0 | 0 | 57.7 Pa | Storey: 2 | NNUK=2.52 m | x0.0 | .0014 | X=13.75 | 21.561
01.0015.01 | 00 Ground floor | 3.00 m | NN=2.80 m | CC= 0.30m FCL | 2.76 m/s | Y=14.36 | Edge= 2.92m SSL | 01 | CC= 3.00m FFB | CC= 3.00m SSL | 200.0 m\X\B3/h | iso= 0.000000 mm | Top= 0.22m FCL | .001 | Supply Air | Office | Dra.no: 1 | 00.18 | 0 | 0 | 55.2 Pa | Storey: 2 | NNUK=2.72 m | x0.0 | .0015 | X=15.94 | 6.56101
01.0015.03 | 00 Ground floor | 2.99 m | NN=2.79 m | CC= 0.31m FCL | 2.76 m/s | Y=14.24 | Edge= 2.92m SSL | 01 | CC= 2.99m FFB | CC= 2.99m SSL | 200.0 m\X\B3/h | iso= 0.000000 mm | Top= 0.25m FCL | .003 | Supply Air | Office | Dra.no: 1 | 00.18 | 0 | 1 | 55.2 Pa | Storey: 2 | NNUK=2.72 m | x0.0 | .0015 | X=15.94 | 762.373
01.0015.05 | 00 Ground floor | 2.80 m | NN=2.60 m | CC= 0.50m FCL | 2.76 m/s | Y=13.38 | Edge= 2.72m SSL | 01 | CC= 2.80m FFB | CC= 2.80m SSL | 200.0 m\X\B3/h | iso= 0.000000 mm | Top= 0.42m FCL | .005 | Supply Air | Office | Dra.no: 1 | 00.18 | 0 | 0 | 55.2 Pa | Storey: 2 | NNUK=2.52 m | x0.0 | .0015 | X=15.94 | 21.561
01.0016.01 | 00 Ground floor | 3.00 m | NN=2.80 m | CC= 0.30m FCL | 2.76 m/s | Y=14.36 | Edge= 2.92m SSL | 01 | CC= 3.00m FFB | CC= 3.00m SSL | 200.0 m\X\B3/h | iso= 0.000000 mm | Top= 0.22m FCL | .001 | Supply Air | Office | Dra.no: 1 | 00.18 | 0 | 0 | 51.5 Pa | Storey: 2 | NNUK=2.72 m | x0.0 | .0016 | X=17.81 | 6.56101
01.0016.03 | 00 Ground floor | 2.99 m | NN=2.79 m | CC= 0.31m FCL | 2.76 m/s | Y=14.24 | Edge= 2.92m SSL | 01 | CC= 2.99m FFB | CC= 2.99m SSL | 200.0 m\X\B3/h | iso= 0.000000 mm | Top= 0.25m FCL | .003 | Supply Air | Office | Dra.no: 1 | 00.18 | 0 | 1 | 51.5 Pa | Storey: 2 | NNUK=2.72 m | x0.0 | .0016 | X=17.81 | 762.373
01.0016.05 | 00 Ground floor | 2.80 m | NN=2.60 m | CC= 0.50m FCL | 2.76 m/s | Y=13.38 | Edge= 2.72m SSL | 01 | CC= 2.80m FFB | CC= 2.80m SSL | 200.0 m\X\B3/h | iso= 0.000000 mm | Top= 0.42m FCL | .005 | Supply Air | Office | Dra.no: 1 | 00.18 | 0 | 0 | 51.5 Pa | Storey: 2 | NNUK=2.52 m | x0.0 | .0016 | X=17.81 | 21.561
01.0017.01 | 00 Ground floor | 3.00 m | NN=2.80 m | CC= 0.30m FCL | 2.76 m/s | Y=18.43 | Edge= 2.92m SSL | 01 | CC= 3.00m FFB | CC= 3.00m SSL | 200.0 m\X\B3/h | iso= 0.000000 mm | Top= 0.22m FCL | .001 | Supply Air | Office | Dra.no: 1 | 001 | 0 | 0 | 82.0 Pa | Storey: 2 | NNUK=2.72 m | x0.0 | .0017 | X=20.06 | 62.7547
01.0017.03 | 00 Ground floor | 2.99 m | NN=2.79 m | CC= 0.31m FCL | 2.76 m/s | Y=18.59 | Edge= 2.92m SSL | 01 | CC= 2.99m FFB | CC= 2.99m SSL | 200.0 m\X\B3/h | iso= 0.000000 mm | Top= 0.24m FCL | .003 | Supply Air | Office | Dra.no: 1 | 001 | 0 | 1 | 82.0 Pa | Storey: 2 | NNUK=2.72 m | x0.0 | .0017 | X=20.06 | 940.06
01.0017.05 | 00 Ground floor | 2.85 m | NN=2.65 m | CC= 0.45m FCL | 2.76 m/s | Y=19.62 | Edge= 2.77m SSL | 01 | CC= 2.85m FFB | CC= 2.85m SSL | 200.0 m\X\B3/h | iso= 0.000000 mm | Top= 0.37m FCL | .005 | Supply Air | Office | Dra.no: 1 | 001 | 0 | 0 | 82.0 Pa | Storey: 2 | NNUK=2.57 m | x0.0 | .0017 | X=20.06 | 28.4367
01.0024.00 | 00 Ground floor | 0.00 m | NN=-0.20 m | CC= 3.50m FCL |  | Y=7.92 | Edge= -0.08m SSL |  | CC= 0.00m FFB | CC= 0.00m SSL |  |  | Top= 3.42m FCL |  |  | Entrance | Dra.no: 1 | 00.01 |  | 1 |  | Storey: 2 | NNUK=-0.28 m | x2.0 |  | X=15.63 | 874.89
01.0025.00 | 00 Ground floor | 0.00 m | NN=-0.20 m | CC= 3.50m FCL |  | Y=7.92 | Edge= -0.08m SSL |  | CC= 0.00m FFB | CC= 0.00m SSL |  |  | Top= 3.42m FCL |  |  | Entrance | Dra.no: 1 | 00.01 |  | 1 |  | Storey: 2 | NNUK=-0.28 m | x2.0 |  | X=19.19 | 874.89
01.0026.00 | 00 Ground floor | 0.00 m | NN=-0.20 m | CC= 3.50m FCL |  | Y=7.92 | Edge= -0.08m SSL |  | CC= 0.00m FFB | CC= 0.00m SSL |  |  | Top= 3.42m FCL |  |  | Entrance | Dra.no: 1 | 00.01 |  | 1 |  | Storey: 2 | NNUK=-0.28 m | x2.0 |  | X=22.75 | 874.89
01.0027.00 | 00 Ground floor | 0.00 m | NN=-0.20 m | CC= 3.50m FCL |  | Y=7.92 | Edge= -0.08m SSL |  | CC= 0.00m FFB | CC= 0.00m SSL |  |  | Top= 3.42m FCL |  |  | Entrance | Dra.no: 1 | 00.01 |  | 1 |  | Storey: 2 | NNUK=-0.28 m | x2.0 |  | X=26.31 | 874.89
01.0028.00 | 00 Ground floor | 0.00 m | NN=-0.20 m | CC= 3.50m FCL |  | Y=7.92 | Edge= -0.08m SSL |  | CC= 0.00m FFB | CC= 0.00m SSL |  |  | Top= 3.42m FCL |  |  | Entrance | Dra.no: 1 | 00.01 |  | 1 |  | Storey: 2 | NNUK=-0.28 m | x2.0 |  | X=29.87 | 874.89
01.0035.01 | 01 First floor | 3.00 m | NN=6.30 m | CC= 0.18m FCL | 2.76 m/s | Y=18.63 | Edge= 3.04m SSL | 01 | CC= 3.12m FFB | CC= 3.12m SSL | 200.0 m\X\B3/h | iso= 0.000000 mm | Top= 0.10m FCL | .001 | Supply Air | Office | Dra.no: 2 | 01.18 | 0 | 0 | 284.4 Pa | Storey: 3 | NNUK=6.22 m | x0.0 | .0035 | X=8.91 | 11.48
01.0035.03 | 01 First floor | 2.99 m | NN=6.29 m | CC= 0.19m FCL | 2.76 m/s | Y=18.74 | Edge= 3.04m SSL | 01 | CC= 3.11m FFB | CC= 3.11m SSL | 200.0 m\X\B3/h | iso= 0.000000 mm | Top= 0.12m FCL | .003 | Supply Air | Office | Dra.no: 2 | 01.18 | 0 | 1 | 284.4 Pa | Storey: 3 | NNUK=6.22 m | x0.0 | .0035 | X=8.91 | 786.874
01.0035.05 | 01 First floor | 2.85 m | NN=6.15 m | CC= 0.33m FCL | 2.76 m/s | Y=19.63 | Edge= 2.89m SSL | 01 | CC= 2.97m FFB | CC= 2.97m SSL | 200.0 m\X\B3/h | iso= 0.000000 mm | Top= 0.25m FCL | .005 | Supply Air | Office | Dra.no: 2 | 01.18 | 0 | 0 | 284.4 Pa | Storey: 3 | NNUK=6.07 m | x0.0 | .0035 | X=8.91 | 26.48
01.0036.01 | 01 First floor | 3.00 m | NN=6.30 m | CC= 0.18m FCL | 2.76 m/s | Y=18.63 | Edge= 3.04m SSL | 01 | CC= 3.12m FFB | CC= 3.12m SSL | 200.0 m\X\B3/h | iso= 0.000000 mm | Top= 0.10m FCL | .001 | Supply Air | Office | Dra.no: 2 | 01.18 | 0 | 0 | 284.1 Pa | Storey: 3 | NNUK=6.22 m | x0.0 | .0036 | X=11.41 | 11.48
01.0036.03 | 01 First floor | 2.99 m | NN=6.29 m | CC= 0.19m FCL | 2.76 m/s | Y=18.74 | Edge= 3.04m SSL | 01 | CC= 3.11m FFB | CC= 3.11m SSL | 200.0 m\X\B3/h | iso= 0.000000 mm | Top= 0.12m FCL | .003 | Supply Air | Office | Dra.no: 2 | 01.18 | 0 | 1 | 284.1 Pa | Storey: 3 | NNUK=6.22 m | x0.0 | .0036 | X=11.41 | 786.874
01.0036.05 | 01 First floor | 2.85 m | NN=6.15 m | CC= 0.33m FCL | 2.76 m/s | Y=19.63 | Edge= 2.89m SSL | 01 | CC= 2.97m FFB | CC= 2.97m SSL | 200.0 m\X\B3/h | iso= 0.000000 mm | Top= 0.25m FCL | .005 | Supply Air | Office | Dra.no: 2 | 01.18 | 0 | 0 | 284.1 Pa | Storey: 3 | NNUK=6.07 m | x0.0 | .0036 | X=11.41 | 26.48
01.0037.01 | 01 First floor | 3.00 m | NN=6.30 m | CC= 0.18m FCL | 2.76 m/s | Y=18.63 | Edge= 3.04m SSL | 01 | CC= 3.12m FFB | CC= 3.12m SSL | 200.0 m\X\B3/h | iso= 0.000000 mm | Top= 0.10m FCL | .001 | Supply Air | Office | Dra.no: 2 | 01.20 | 0 | 0 | 283.8 Pa | Storey: 3 | NNUK=6.22 m | x0.0 | .0037 | X=13.69 | 11.48
01.0037.03 | 01 First floor | 2.99 m | NN=6.29 m | CC= 0.19m FCL | 2.76 m/s | Y=18.74 | Edge= 3.04m SSL | 01 | CC= 3.11m FFB | CC= 3.11m SSL | 200.0 m\X\B3/h | iso= 0.000000 mm | Top= 0.12m FCL | .003 | Supply Air | Office | Dra.no: 2 | 01.20 | 0 | 1 | 283.8 Pa | Storey: 3 | NNUK=6.22 m | x0.0 | .0037 | X=13.69 | 786.874
01.0037.05 | 01 First floor | 2.85 m | NN=6.15 m | CC= 0.33m FCL | 2.76 m/s | Y=19.63 | Edge= 2.89m SSL | 01 | CC= 2.97m FFB | CC= 2.97m SSL | 200.0 m\X\B3/h | iso= 0.000000 mm | Top= 0.25m FCL | .005 | Supply Air | Office | Dra.no: 2 | 01.20 | 0 | 0 | 283.8 Pa | Storey: 3 | NNUK=6.07 m | x0.0 | .0037 | X=13.69 | 26.48
01.0038.01 | 01 First floor | 3.00 m | NN=6.30 m | CC= 0.18m FCL | 2.76 m/s | Y=18.63 | Edge= 3.04m SSL | 01 | CC= 3.12m FFB | CC= 3.12m SSL | 200.0 m\X\B3/h | iso= 0.000000 mm | Top= 0.10m FCL | .001 | Supply Air | Office | Dra.no: 2 | 01.20 | 0 | 0 | 283.6 Pa | Storey: 3 | NNUK=6.22 m | x0.0 | .0038 | X=15.56 | 11.48
01.0038.03 | 01 First floor | 2.99 m | NN=6.29 m | CC= 0.19m FCL | 2.76 m/s | Y=18.74 | Edge= 3.04m SSL | 01 | CC= 3.11m FFB | CC= 3.11m SSL | 200.0 m\X\B3/h | iso= 0.000000 mm | Top= 0.12m FCL | .003 | Supply Air | Office | Dra.no: 2 | 01.20 | 0 | 1 | 283.6 Pa | Storey: 3 | NNUK=6.22 m | x0.0 | .0038 | X=15.56 | 786.874
01.0038.05 | 01 First floor | 2.85 m | NN=6.15 m | CC= 0.33m FCL | 2.76 m/s | Y=19.63 | Edge= 2.89m SSL | 01 | CC= 2.97m FFB | CC= 2.97m SSL | 200.0 m\X\B3/h | iso= 0.000000 mm | Top= 0.25m FCL | .005 | Supply Air | Office | Dra.no: 2 | 01.20 | 0 | 0 | 283.6 Pa | Storey: 3 | NNUK=6.07 m | x0.0 | .0038 | X=15.56 | 26.48
01.0039.01 | 01 First floor | 3.00 m | NN=6.30 m | CC= 0.18m FCL | 2.76 m/s | Y=18.63 | Edge= 3.04m SSL | 01 | CC= 3.12m FFB | CC= 3.12m SSL | 200.0 m\X\B3/h | iso= 0.000000 mm | Top= 0.10m FCL | .001 | Supply Air | Office | Dra.no: 2 | 01.19 | 0 | 0 | 283.3 Pa | Storey: 3 | NNUK=6.22 m | x0.0 | .0039 | X=18.19 | 11.48
01.0039.03 | 01 First floor | 2.99 m | NN=6.29 m | CC= 0.19m FCL | 2.76 m/s | Y=18.74 | Edge= 3.04m SSL | 01 | CC= 3.11m FFB | CC= 3.11m SSL | 200.0 m\X\B3/h | iso= 0.000000 mm | Top= 0.12m FCL | .003 | Supply Air | Office | Dra.no: 2 | 01.19 | 0 | 1 | 283.3 Pa | Storey: 3 | NNUK=6.22 m | x0.0 | .0039 | X=18.19 | 786.874
01.0039.05 | 01 First floor | 2.85 m | NN=6.15 m | CC= 0.33m FCL | 2.76 m/s | Y=19.63 | Edge= 2.89m SSL | 01 | CC= 2.97m FFB | CC= 2.97m SSL | 200.0 m\X\B3/h | iso= 0.000000 mm | Top= 0.25m FCL | .005 | Supply Air | Office | Dra.no: 2 | 01.19 | 0 | 0 | 283.3 Pa | Storey: 3 | NNUK=6.07 m | x0.0 | .0039 | X=18.19 | 26.48
01.0040.01 | 01 First floor | 3.00 m | NN=6.30 m | CC= 0.18m FCL | 2.76 m/s | Y=18.63 | Edge= 3.04m SSL | 01 | CC= 3.12m FFB | CC= 3.12m SSL | 200.0 m\X\B3/h | iso= 0.000000 mm | Top= 0.10m FCL | .001 | Supply Air | Office | Dra.no: 2 | 01.19 | 0 | 0 | 283.0 Pa | Storey: 3 | NNUK=6.22 m | x0.0 | .0040 | X=20.06 | 11.48
01.0040.03 | 01 First floor | 2.99 m | NN=6.29 m | CC= 0.19m FCL | 2.76 m/s | Y=18.74 | Edge= 3.04m SSL | 01 | CC= 3.11m FFB | CC= 3.11m SSL | 200.0 m\X\B3/h | iso= 0.000000 mm | Top= 0.12m FCL | .003 | Supply Air | Office | Dra.no: 2 | 01.19 | 0 | 1 | 283.0 Pa | Storey: 3 | NNUK=6.22 m | x0.0 | .0040 | X=20.06 | 786.874
01.0040.05 | 01 First floor | 2.85 m | NN=6.15 m | CC= 0.33m FCL | 2.76 m/s | Y=19.63 | Edge= 2.89m SSL | 01 | CC= 2.97m FFB | CC= 2.97m SSL | 200.0 m\X\B3/h | iso= 0.000000 mm | Top= 0.25m FCL | .005 | Supply Air | Office | Dra.no: 2 | 01.19 | 0 | 0 | 283.0 Pa | Storey: 3 | NNUK=6.07 m | x0.0 | .0040 | X=20.06 | 26.48
01.0041.01 | 01 First floor | 3.00 m | NN=6.30 m | CC= 0.18m FCL | 2.76 m/s | Y=18.63 | Edge= 3.04m SSL | 01 | CC= 3.12m FFB | CC= 3.12m SSL | 200.0 m\X\B3/h | iso= 0.000000 mm | Top= 0.10m FCL | .001 | Supply Air | Storage | Dra.no: 2 | 01.13 | 0 | 0 | 282.7 Pa | Storey: 3 | NNUK=6.22 m | x0.0 | .0041 | X=22.19 | 11.48
01.0041.03 | 01 First floor | 2.99 m | NN=6.29 m | CC= 0.19m FCL | 2.76 m/s | Y=18.74 | Edge= 3.04m SSL | 01 | CC= 3.11m FFB | CC= 3.11m SSL | 200.0 m\X\B3/h | iso= 0.000000 mm | Top= 0.12m FCL | .003 | Supply Air | Storage | Dra.no: 2 | 01.13 | 0 | 1 | 282.7 Pa | Storey: 3 | NNUK=6.22 m | x0.0 | .0041 | X=22.19 | 786.874
01.0041.05 | 01 First floor | 2.85 m | NN=6.15 m | CC= 0.33m FCL | 2.76 m/s | Y=19.63 | Edge= 2.89m SSL | 01 | CC= 2.97m FFB | CC= 2.97m SSL | 200.0 m\X\B3/h | iso= 0.000000 mm | Top= 0.25m FCL | .005 | Supply Air | Storage | Dra.no: 2 | 01.13 | 0 | 0 | 282.7 Pa | Storey: 3 | NNUK=6.07 m | x0.0 | .0041 | X=22.19 | 26.48

# IfcFlowSegment: SS8310125 (43)
In: 00 Ground floor
Type - Description: Folded Spiral-seam Circ DIN 24145 d 125; ApplicableOccurrence: Circ; PredefinedType: RIGIDSEGMENT
Type - Pset_ManufacturerTypeInformation - ArticleNumber: SS8310125; ModelReference: Folded Spiral-seam Circ DIN 24145 d 125; Manufacturer: DDS
Type - Pset_DuctSegmentTypeCommon - NominalDiameterOrWidth: 125
Material: ML-Folded Spiral-seam Circ DIN 24145 d 125
Pset_DDS - Manufacturer: DDS; Width: 125; Iso thickness: iso= 0.000000 mm; Dimension DN: 125 mm; Model Number: Dra.no: 1; Product Number: SS8310125; Project name: OpenBIM; Height: 0; Insulation WSVO: 0; Insulation k-value: 0; Floor number: Storey: 2; Product: Folded Spiral-seam Circ DIN 24145 d 125; Flowsegment thickness: x0.0; Building Part: Building: 0
AC_Pset_RenovationAndPhasing - Renovation Status: Existing
Name | Pset_FlowSegmentDuctSegment, Length (mm) | Mtg. Above Slab ref Center | Mounting Height | X | Velocity | Above Sea Level ref. Center | Main string number | Flow | Abs. pressure | System Name | Part number | Medium | Sub string number | Mtg. Below Ceiling ref Center | Room tekst | Mtg. Above Slab ref Bottom | Layer number | Room number | Pset_DDS, Length | Above Sea Level ref. Bottom | Mtg. Below Ceiling ref Top | Mtg. above Finished Floor ref Center | Y | Group
01.0019.01 | 350.336 | CC= 3.12m SSL | 3.00 m | X=38.19 | 2.44 m/s | NN=2.80 m | 01 | 108.0 m\X\B3/h | 216.9 Pa | Supply Air | .001 | Supply Air | .0019 | CC= 0.18m FCL | Office | Edge= 3.06m SSL | 10 | 00.23 | 0 | NNUK=2.74 m | Top= 0.12m FCL | CC= 3.12m FFB | Y=17.78 | Supply air
01.0019.03 | 247.013 | CC= 2.98m SSL | 2.86 m | X=38.19 | 2.44 m/s | NN=2.66 m | 01 | 108.0 m\X\B3/h | 216.9 Pa | Supply Air | .003 | Supply Air | .0019 | CC= 0.32m FCL | Office | Edge= 2.85m SSL | 10 | 00.23 | 0 | NNUK=2.53 m | Top= 0.20m FCL | CC= 2.98m FFB | Y=17.51 | Supply air
01.0019.05 | 1270.79 | CC= 2.96m SSL | 2.84 m | X=38.19 | 2.44 m/s | NN=2.64 m | 01 | 108.0 m\X\B3/h | 216.9 Pa | Supply Air | .005 | Supply Air | .0019 | CC= 0.34m FCL | Office | Edge= 2.90m SSL | 10 | 00.23 | 1 | NNUK=2.58 m | Top= 0.27m FCL | CC= 2.96m FFB | Y=16.17 | Supply air
01.0019.07 | 60.8725 | CC= 2.96m SSL | 2.84 m | X=38.38 | 2.44 m/s | NN=2.64 m | 01 | 108.0 m\X\B3/h | 216.9 Pa | Supply Air | .007 | Supply Air | .0019 | CC= 0.34m FCL | Office | Edge= 2.90m SSL | 10 | 00.23 | 0 | NNUK=2.58 m | Top= 0.27m FCL | CC= 2.96m FFB | Y=16.05 | Supply air
01.0020.01 | 287.526 | CC= 3.12m SSL | 3.00 m | X=38.19 | 2.44 m/s | NN=2.80 m | 01 | 108.0 m\X\B3/h | 217.5 Pa | Supply Air | .001 | Supply Air | .0020 | CC= 0.18m FCL | Office | Edge= 3.06m SSL | 10 | 00.23 | 0 | NNUK=2.74 m | Top= 0.12m FCL | CC= 3.12m FFB | Y=18.70 | Supply air
01.0020.03 | 247.013 | CC= 2.98m SSL | 2.86 m | X=38.19 | 2.44 m/s | NN=2.66 m | 01 | 108.0 m\X\B3/h | 217.5 Pa | Supply Air | .003 | Supply Air | .0020 | CC= 0.32m FCL | Office | Edge= 2.85m SSL | 10 | 00.23 | 0 | NNUK=2.53 m | Top= 0.20m FCL | CC= 2.98m FFB | Y=18.98 | Supply air
01.0020.05 | 633.514 | CC= 2.96m SSL | 2.84 m | X=38.19 | 2.44 m/s | NN=2.64 m | 01 | 108.0 m\X\B3/h | 217.5 Pa | Supply Air | .005 | Supply Air | .0020 | CC= 0.34m FCL | Office | Edge= 2.90m SSL | 10 | 00.23 | 1 | NNUK=2.58 m | Top= 0.27m FCL | CC= 2.96m FFB | Y=19.67 | Supply air
01.0020.07 | 60.8725 | CC= 2.96m SSL | 2.84 m | X=38.38 | 2.44 m/s | NN=2.64 m | 01 | 108.0 m\X\B3/h | 217.5 Pa | Supply Air | .007 | Supply Air | .0020 | CC= 0.34m FCL | Office | Edge= 2.90m SSL | 10 | 00.23 | 0 | NNUK=2.58 m | Top= 0.27m FCL | CC= 2.96m FFB | Y=19.80 | Supply air
01.0021.01 | 115.506 | CC= 3.12m SSL | 3.00 m | X=34.97 | 2.44 m/s | NN=2.80 m | 01 | 108.0 m\X\B3/h | 218.2 Pa | Supply Air | .001 | Supply Air | .0021 | CC= 0.18m FCL | Office | Edge= 3.06m SSL | 10 | 00.23 | 0 | NNUK=2.74 m | Top= 0.12m FCL | CC= 3.12m FFB | Y=18.55 | Supply air
01.0021.03 | 247.013 | CC= 2.98m SSL | 2.86 m | X=34.97 | 2.44 m/s | NN=2.66 m | 01 | 108.0 m\X\B3/h | 218.2 Pa | Supply Air | .003 | Supply Air | .0021 | CC= 0.32m FCL | Office | Edge= 2.85m SSL | 10 | 00.23 | 0 | NNUK=2.53 m | Top= 0.20m FCL | CC= 2.98m FFB | Y=18.83 | Supply air
01.0021.05 | 780.534 | CC= 2.96m SSL | 2.84 m | X=34.97 | 2.44 m/s | NN=2.64 m | 01 | 108.0 m\X\B3/h | 218.2 Pa | Supply Air | .005 | Supply Air | .0021 | CC= 0.34m FCL | Office | Edge= 2.90m SSL | 10 | 00.23 | 1 | NNUK=2.58 m | Top= 0.27m FCL | CC= 2.96m FFB | Y=19.67 | Supply air
01.0021.07 | 160.038 | CC= 2.96m SSL | 2.84 m | X=35.26 | 2.44 m/s | NN=2.64 m | 01 | 108.0 m\X\B3/h | 218.2 Pa | Supply Air | .007 | Supply Air | .0021 | CC= 0.34m FCL | Office | Edge= 2.90m SSL | 10 | 00.23 | 0 | NNUK=2.58 m | Top= 0.27m FCL | CC= 2.96m FFB | Y=19.80 | Supply air
01.0022.01 | 2.0444 | CC= 3.12m SSL | 3.00 m | X=34.97 | 2.44 m/s | NN=2.80 m | 01 | 108.0 m\X\B3/h | 217.6 Pa | Supply Air | .001 | Supply Air | .0022 | CC= 0.18m FCL | Office | Edge= 3.06m SSL | 10 | 00.23 | 0 | NNUK=2.74 m | Top= 0.12m FCL | CC= 3.12m FFB | Y=18.11 | Supply air
01.0022.03 | 298.616 | CC= 2.98m SSL | 2.86 m | X=34.97 | 2.44 m/s | NN=2.66 m | 01 | 108.0 m\X\B3/h | 217.6 Pa | Supply Air | .003 | Supply Air | .0022 | CC= 0.32m FCL | Office | Edge= 2.86m SSL | 10 | 00.23 | 0 | NNUK=2.54 m | Top= 0.21m FCL | CC= 2.98m FFB | Y=17.79 | Supply air
01.0022.05 | 1558.9 | CC= 2.96m SSL | 2.84 m | X=34.97 | 2.44 m/s | NN=2.64 m | 01 | 108.0 m\X\B3/h | 217.6 Pa | Supply Air | .005 | Supply Air | .0022 | CC= 0.34m FCL | Office | Edge= 2.90m SSL | 10 | 00.23 | 2 | NNUK=2.58 m | Top= 0.27m FCL | CC= 2.96m FFB | Y=16.17 | Supply air
01.0022.07 | 160.038 | CC= 2.96m SSL | 2.84 m | X=35.26 | 2.44 m/s | NN=2.64 m | 01 | 108.0 m\X\B3/h | 217.6 Pa | Supply Air | .007 | Supply Air | .0022 | CC= 0.34m FCL | Office | Edge= 2.90m SSL | 10 | 00.23 | 0 | NNUK=2.58 m | Top= 0.27m FCL | CC= 2.96m FFB | Y=16.05 | Supply air
01.0031.03 | 3352.96 | CC= 2.87m SSL | 3.00 m | X=35.27 | 2.26 m/s | NN=2.80 m | 01 | 100.0 m\X\B3/h | 248.8 Pa | Supply Air | .003 | Supply Air | .0031 | CC= 0.43m FCL | Director office | Edge= 2.81m SSL | 10 | 00.25 | 3 | NNUK=2.74 m | Top= 0.37m FCL | CC= 2.87m FFB | Y=9.28 | Supply air
01.0031.06 | 101.512 | CC= 3.12m SSL | 3.00 m | X=38.75 | 2.26 m/s | NN=2.80 m | 01 | 100.0 m\X\B3/h | 248.8 Pa | Supply Air | .006 | Supply Air | .0031 | CC= 0.18m FCL | Director office | Edge= 3.06m SSL | 10 | 00.24 | 0 | NNUK=2.74 m | Top= 0.12m FCL | CC= 3.12m FFB | Y=9.15 | Supply air
01.0031.08 | 179.289 | CC= 3.08m SSL | 2.96 m | X=38.75 | 2.26 m/s | NN=2.76 m | 01 | 100.0 m\X\B3/h | 248.8 Pa | Supply Air | .008 | Supply Air | .0031 | CC= 0.22m FCL | Director office | Edge= 3.05m SSL | 10 | 00.24 | 0 | NNUK=2.73 m | Top= 0.18m FCL | CC= 3.08m FFB | Y=8.96 | Supply air
01.0031.10 | 161.324 | CC= 2.92m SSL | 2.80 m | X=38.75 | 2.26 m/s | NN=2.60 m | 01 | 100.0 m\X\B3/h | 248.8 Pa | Supply Air | .010 | Supply Air | .0031 | CC= 0.38m FCL | Director office | Edge= 2.86m SSL | 10 | 00.24 | 0 | NNUK=2.54 m | Top= 0.32m FCL | CC= 2.92m FFB | Y=8.75 | Supply air
01.0032.01 | 33.2236 | CC= 2.87m SSL | 3.00 m | X=35.00 | 2.26 m/s | NN=2.80 m | 01 | 100.0 m\X\B3/h | 242.8 Pa | Supply Air | .001 | Supply Air | .0032 | CC= 0.43m FCL | Director office | Edge= 2.81m SSL | 10 | 00.25 | 0 | NNUK=2.74 m | Top= 0.37m FCL | CC= 2.87m FFB | Y=9.16 | Supply air
01.0032.03 | 179.289 | CC= 2.83m SSL | 2.96 m | X=35.00 | 2.26 m/s | NN=2.76 m | 01 | 100.0 m\X\B3/h | 242.8 Pa | Supply Air | .003 | Supply Air | .0032 | CC= 0.47m FCL | Director office | Edge= 2.80m SSL | 10 | 00.25 | 0 | NNUK=2.73 m | Top= 0.43m FCL | CC= 2.83m FFB | Y=9.04 | Supply air
01.0032.05 | 239.012 | CC= 2.67m SSL | 2.80 m | X=35.00 | 2.26 m/s | NN=2.60 m | 01 | 100.0 m\X\B3/h | 242.8 Pa | Supply Air | .005 | Supply Air | .0032 | CC= 0.63m FCL | Director office | Edge= 2.61m SSL | 10 | 00.25 | 0 | NNUK=2.54 m | Top= 0.57m FCL | CC= 2.67m FFB | Y=8.83 | Supply air
01.0033.01 | 23.2236 | CC= 2.87m SSL | 3.00 m | X=33.12 | 2.26 m/s | NN=2.80 m | 01 | 100.0 m\X\B3/h | 243.9 Pa | Supply Air | .001 | Supply Air | .0033 | CC= 0.43m FCL | Director office | Edge= 2.81m SSL | 10 | 00.25 | 0 | NNUK=2.74 m | Top= 0.37m FCL | CC= 2.87m FFB | Y=9.15 | Supply air
01.0033.03 | 179.289 | CC= 2.83m SSL | 2.96 m | X=33.12 | 2.26 m/s | NN=2.76 m | 01 | 100.0 m\X\B3/h | 243.9 Pa | Supply Air | .003 | Supply Air | .0033 | CC= 0.47m FCL | Director office | Edge= 2.80m SSL | 10 | 00.25 | 0 | NNUK=2.73 m | Top= 0.43m FCL | CC= 2.83m FFB | Y=9.04 | Supply air
01.0033.05 | 239.012 | CC= 2.67m SSL | 2.80 m | X=33.12 | 2.26 m/s | NN=2.60 m | 01 | 100.0 m\X\B3/h | 243.9 Pa | Supply Air | .005 | Supply Air | .0033 | CC= 0.63m FCL | Director office | Edge= 2.61m SSL | 10 | 00.25 | 0 | NNUK=2.54 m | Top= 0.57m FCL | CC= 2.67m FFB | Y=8.83 | Supply air
Duct | 175 | CC= 2.87m SSL | 2.87 m | X=21.44 | 0.00 m/s | NN=2.67 m | 00 | 0.0 m\X\B3/h | 0.0 Pa |  | .015 | Extract Air | .0000 | CC= 0.42m FCL | corridor | Edge= 2.81m SSL | 11 | 00.04 | 0 | NNUK=2.61 m | Top= 0.36m FCL | CC= 2.87m FFB | Y=13.30
Duct | 273.572 | CC= 2.70m SSL | 2.70 m | X=10.94 | 0.00 m/s | NN=2.50 m | 00 | 0.0 m\X\B3/h | 0.0 Pa |  | .000 | Extract Air | .0000 | CC= 0.60m FCL | Storage | Edge= 2.64m SSL | 11 | 00.13 | 0 | NNUK=2.44 m | Top= 0.54m FCL | CC= 2.70m FFB | Y=13.19
Duct | 670.487 | CC= 3.10m SSL | 3.10 m | X=11.06 | 0.00 m/s | NN=2.90 m | 00 | 0.0 m\X\B3/h | 0.0 Pa |  | .000 | Extract Air | .0000 | CC= 0.20m FCL | Storage | Edge= 3.04m SSL | 11 | 00.13 | 1 | NNUK=2.84 m | Top= 0.14m FCL | CC= 3.10m FFB | Y=13.19
Duct | 175 | CC= 2.88m SSL | 2.88 m | X=19.56 | 0.00 m/s | NN=2.68 m | 00 | 0.0 m\X\B3/h | 0.0 Pa |  | .015 | Extract Air | .0000 | CC= 0.42m FCL | wc | Edge= 2.81m SSL | 11 | 00.07 | 0 | NNUK=2.61 m | Top= 0.36m FCL | CC= 2.88m FFB | Y=14.54
Duct | 981.228 | CC= 3.00m SSL | 3.00 m | X=20.33 | 0.00 m/s | NN=2.80 m | 00 | 0.0 m\X\B3/h | 0.0 Pa |  | .015 | Extract Air | .0000 | CC= 0.30m FCL | corridor | Edge= 2.94m SSL | 11 | 00.04 | 1 | NNUK=2.74 m | Top= 0.24m FCL | CC= 3.00m FFB | Y=13.30
Duct | 276.92 | CC= 3.10m SSL | 3.10 m | X=11.80 | 0.00 m/s | NN=2.90 m | 00 | 0.0 m\X\B3/h | 0.0 Pa |  | .015 | Extract Air | .0000 | CC= 0.20m FCL | Storage | Edge= 3.04m SSL | 11 | 00.13 | 0 | NNUK=2.84 m | Top= 0.14m FCL | CC= 3.10m FFB | Y=13.17
Duct | 8021.55 | CC= 3.10m SSL | 3.10 m | X=12.10 | 0.00 m/s | NN=2.90 m | 00 | 0.0 m\X\B3/h | 0.0 Pa |  | .015 | Extract Air | .0000 | CC= 0.20m FCL | Storage | Edge= 3.04m SSL | 11 | 00.13 | 8 | NNUK=2.84 m | Top= 0.14m FCL | CC= 3.10m FFB | Y=13.02
Duct | 175 | CC= 2.88m SSL | 2.88 m | X=19.56 | 0.00 m/s | NN=2.68 m | 00 | 0.0 m\X\B3/h | 0.0 Pa |  | .015 | Extract Air | .0000 | CC= 0.42m FCL | wc | Edge= 2.81m SSL | 11 | 00.08 | 0 | NNUK=2.61 m | Top= 0.36m FCL | CC= 2.88m FFB | Y=13.85
Duct | 388.772 | CC= 3.00m SSL | 3.00 m | X=20.07 | 0.00 m/s | NN=2.80 m | 00 | 0.0 m\X\B3/h | 0.0 Pa |  | .015 | Extract Air | .0000 | CC= 0.30m FCL | corridor | Edge= 2.94m SSL | 11 | 00.04 | 0 | NNUK=2.74 m | Top= 0.24m FCL | CC= 3.00m FFB | Y=13.85
Duct | 1406.65 | CC= 3.00m SSL | 3.00 m | X=22.58 | 0.00 m/s | NN=2.80 m | 00 | 0.0 m\X\B3/h | 0.0 Pa |  | .015 | Extract Air | .0000 | CC= 0.30m FCL | Storage | Edge= 2.94m SSL | 11 | 00.22 | 1 | NNUK=2.74 m | Top= 0.24m FCL | CC= 3.00m FFB | Y=17.44
Duct | 175 | CC= 2.70m SSL | 2.70 m | X=22.58 | 0.00 m/s | NN=2.50 m | 00 | 0.0 m\X\B3/h | 0.0 Pa |  | .015 | Extract Air | .0000 | CC= 0.60m FCL | Storage | Edge= 2.64m SSL | 11 | 00.22 | 0 | NNUK=2.44 m | Top= 0.54m FCL | CC= 2.70m FFB | Y=17.56
Duct | 388.772 | CC= 3.00m SSL | 3.00 m | X=20.07 | 0.00 m/s | NN=2.80 m | 00 | 0.0 m\X\B3/h | 0.0 Pa |  | .015 | Extract Air | .0000 | CC= 0.30m FCL | corridor | Edge= 2.94m SSL | 11 | 00.04 | 0 | NNUK=2.74 m | Top= 0.24m FCL | CC= 3.00m FFB | Y=14.54
Duct | 175 | CC= 2.88m SSL | 2.88 m | X=23.31 | 0.00 m/s | NN=2.68 m | 00 | 0.0 m\X\B3/h | 0.0 Pa |  | .015 | Extract Air | .0000 | CC= 0.42m FCL | wc | Edge= 2.81m SSL | 11 | 00.09 | 0 | NNUK=2.61 m | Top= 0.36m FCL | CC= 2.88m FFB | Y=13.91
Duct | 235.204 | CC= 3.00m SSL | 3.00 m | X=23.67 | 0.00 m/s | NN=2.80 m | 00 | 0.0 m\X\B3/h | 0.0 Pa |  | .015 | Extract Air | .0000 | CC= 0.30m FCL | Hallway | Edge= 2.94m SSL | 11 | 00.03 | 0 | NNUK=2.74 m | Top= 0.24m FCL | CC= 3.00m FFB | Y=13.91
Duct | 175 | CC= 2.88m SSL | 2.88 m | X=23.31 | 0.00 m/s | NN=2.68 m | 00 | 0.0 m\X\B3/h | 0.0 Pa |  | .015 | Extract Air | .0000 | CC= 0.42m FCL | wc | Edge= 2.81m SSL | 11 | 00.10 | 0 | NNUK=2.61 m | Top= 0.36m FCL | CC= 2.88m FFB | Y=12.66
Duct | 351.549 | CC= 3.00m SSL | 3.00 m | X=23.72 | 0.00 m/s | NN=2.80 m | 00 | 0.0 m\X\B3/h | 0.0 Pa |  | .015 | Extract Air | .0000 | CC= 0.30m FCL | Hallway | Edge= 2.94m SSL | 11 | 00.03 | 0 | NNUK=2.74 m | Top= 0.24m FCL | CC= 3.00m FFB | Y=12.90
Duct | 268.898 | CC= 3.00m SSL | 3.00 m | X=23.79 | 0.00 m/s | NN=2.80 m | 00 | 0.0 m\X\B3/h | 0.0 Pa |  | .015 | Extract Air | .0000 | CC= 0.30m FCL | Hallway | Edge= 2.94m SSL | 11 | 00.03 | 0 | NNUK=2.74 m | Top= 0.24m FCL | CC= 3.00m FFB | Y=13.28

# IfcFlowSegment: SS8310140 (6)
In: 00 Ground floor
Type - Description: Folded Spiral-seam Circ DIN 24145 d 140; ApplicableOccurrence: Circ; PredefinedType: RIGIDSEGMENT
Type - Pset_ManufacturerTypeInformation - ArticleNumber: SS8310140; ModelReference: Folded Spiral-seam Circ DIN 24145 d 140; Manufacturer: DDS
Type - Pset_DuctSegmentTypeCommon - NominalDiameterOrWidth: 140
Material: ML-Folded Spiral-seam Circ DIN 24145 d 140
Pset_DDS - Width: 140; Manufacturer: DDS; Iso thickness: iso= 0.000000 mm; Product Number: SS8310140; Model Number: Dra.no: 1; Product: Folded Spiral-seam Circ DIN 24145 d 140; Project name: OpenBIM; Height: 0; Insulation WSVO: 0; Insulation k-value: 0; Floor number: Storey: 2; Flowsegment thickness: x0.0; Dimension DN: 140 mm; Building Part: Building: 0
AC_Pset_RenovationAndPhasing - Renovation Status: Existing
Name | Pset_FlowSegmentDuctSegment, Length (mm) | Mounting Height | Above Sea Level ref. Center | Mtg. Below Ceiling ref Center | Part number | Main string number | Sub string number | Y | X | Flow | Mtg. above Finished Floor ref Center | Medium | Layer number | Room number | Pset_DDS, Length | Mtg. Above Slab ref Center | Velocity | Above Sea Level ref. Bottom | Abs. pressure | Room tekst | Mtg. Above Slab ref Bottom | Mtg. Below Ceiling ref Top
01.0030.03 | 1506.22 | 3.00 m | NN=2.80 m | CC= 0.43m FCL | .003 | 01 | .0030 | Y=9.28 | X=33.39 | 200.0 m\X\B3/h | CC= 2.87m FFB | Supply Air | 10 | 00.25 | 2 | CC= 2.87m SSL | 3.61 m/s | NNUK=2.73 m | 252.1 Pa | Director office | Edge= 2.80m SSL | Top= 0.36m FCL | Pset_DDS - System Name: Supply Air; Group: Supply air
Duct | 1384.96 | 3.00 m | NN=2.80 m | CC= 0.30m FCL | .015 | 00 | .0000 | Y=15.40 | X=23.79 | 0.0 m\X\B3/h | CC= 3.00m FFB | Extract Air | 11 | 00.03 | 1 | CC= 3.00m SSL | 0.00 m/s | NNUK=2.73 m | 0.0 Pa | Hallway | Edge= 2.93m SSL | Top= 0.23m FCL
Duct | 160.038 | 2.86 m | NN=2.66 m | CC= 0.44m FCL | .015 | 00 | .0000 | Y=12.65 | X=19.56 | 0.0 m\X\B3/h | CC= 2.86m FFB | Extract Air | 11 | 00.06 | 0 | CC= 2.86m SSL | 0.00 m/s | NNUK=2.59 m | 0.0 Pa | wc | Edge= 2.79m SSL | Top= 0.37m FCL
Duct | 263.772 | 3.00 m | NN=2.80 m | CC= 0.30m FCL | .015 | 00 | .0000 | Y=12.65 | X=19.96 | 0.0 m\X\B3/h | CC= 3.00m FFB | Extract Air | 11 | 00.06 | 0 | CC= 3.00m SSL | 0.00 m/s | NNUK=2.73 m | 0.0 Pa | wc | Edge= 2.93m SSL | Top= 0.23m FCL
Duct | 110 | 3.00 m | NN=2.80 m | CC= 0.30m FCL | .015 | 00 | .0000 | Y=12.65 | X=20.07 | 0.0 m\X\B3/h | CC= 3.00m FFB | Extract Air | 11 | 00.04 | 0 | CC= 3.00m SSL | 0.00 m/s | NNUK=2.73 m | 0.0 Pa | corridor | Edge= 2.93m SSL | Top= 0.23m FCL
Duct | 70.1355 | 3.00 m | NN=2.80 m | CC= 0.30m FCL | .015 | 00 | .0000 | Y=12.86 | X=20.21 | 0.0 m\X\B3/h | CC= 3.00m FFB | Extract Air | 11 | 00.04 | 0 | CC= 3.00m SSL | 0.00 m/s | NNUK=2.73 m | 0.0 Pa | corridor | Edge= 2.93m SSL | Top= 0.23m FCL

# IfcFlowSegment: SS8310160 (7)
In: 00 Ground floor
Type - Description: Folded Spiral-seam Circ DIN 24145 d 160; ApplicableOccurrence: Circ; PredefinedType: RIGIDSEGMENT
Type - Pset_ManufacturerTypeInformation - ArticleNumber: SS8310160; ModelReference: Folded Spiral-seam Circ DIN 24145 d 160; Manufacturer: DDS
Type - Pset_DuctSegmentTypeCommon - NominalDiameterOrWidth: 160
Material: ML-Folded Spiral-seam Circ DIN 24145 d 160
Pset_DDS - Mounting Height: 3.00 m; Product Number: SS8310160; Above Sea Level ref. Center: NN=2.80 m; Manufacturer: DDS; Iso thickness: iso= 0.000000 mm; Model Number: Dra.no: 1; Product: Folded Spiral-seam Circ DIN 24145 d 160; Project name: OpenBIM; Height: 0; Length: 0; Insulation WSVO: 0; Insulation k-value: 0; Floor number: Storey: 2; Flowsegment thickness: x0.0; Building Part: Building: 0
AC_Pset_RenovationAndPhasing - Renovation Status: Existing
Name | Dimension DN | Mtg. Below Ceiling ref Center | Main string number | Y | Mtg. above Finished Floor ref Center | System Name | Medium | Layer number | Room number | Mtg. Above Slab ref Center | Flow | Mtg. Above Slab ref Bottom | Above Sea Level ref. Bottom | Part number | Width | Sub string number | X | Room tekst | Mtg. Below Ceiling ref Top | Abs. pressure | Velocity | Length (mm) | Group
01.0000.00 | 160 mm | CC= 0.43m FCL | 01 | Y=9.28 | CC= 2.87m FFB | Supply Air | Supply Air | 10 | 00.25 | CC= 2.87m SSL | 0.0 m\X\B3/h | Edge= 2.79m SSL | NNUK=2.72 m | .000 | 160 | .0000 | X=32.57 | Director office | Top= 0.35m FCL | 0.0 Pa | 0.00 m/s | 403.398 | Supply air
01.0000.05 | 160 mm | CC= 0.43m FCL | 01 | Y=9.28 | CC= 2.87m FFB | Supply Air | Supply Air | 10 | 00.25 | CC= 2.87m SSL | 0.0 m\X\B3/h | Edge= 2.79m SSL | NNUK=2.72 m | .005 | 160 | .0000 | X=32.98 | Director office | Top= 0.35m FCL | 0.0 Pa | 0.00 m/s | 42.627 | Supply air
01.0030.01 | 160 mm | CC= 0.43m FCL | 01 | Y=9.28 | CC= 2.87m FFB | Supply Air | Supply Air | 10 | 00.25 | CC= 2.87m SSL | 200.0 m\X\B3/h | Edge= 2.79m SSL | NNUK=2.72 m | .001 | 160 | .0030 | X=33.22 | Director office | Top= 0.35m FCL | 252.4 Pa | 2.76 m/s | 118.782 | Supply air
01.0031.01 | 140 mm | CC= 0.43m FCL | 01 | Y=9.28 | CC= 2.87m FFB | Supply Air | Supply Air | 10 | 00.25 | CC= 2.87m SSL | 100.0 m\X\B3/h | Edge= 2.80m SSL | NNUK=2.73 m | .001 | 140 | .0031 | X=35.10 | Director office | Top= 0.36m FCL | 248.9 Pa | 1.80 m/s | 124.536 | Supply air
Duct | 140 mm | CC= 0.30m FCL | 00 | Y=13.81 | CC= 3.00m FFB |  | Extract Air | 11 | 00.03 | CC= 3.00m SSL | 0.0 m\X\B3/h | Edge= 2.93m SSL | NNUK=2.73 m | .015 | 140 | .0000 | X=23.79 | Hallway | Top= 0.23m FCL | 0.0 Pa | 0.00 m/s | 487.074
Duct | 160 mm | CC= 0.30m FCL | 00 | Y=13.02 | CC= 3.00m FFB |  | Extract Air | 11 | 00.04 | CC= 3.00m SSL | 0.0 m\X\B3/h | Edge= 2.92m SSL | NNUK=2.72 m | .015 | 160 | .0000 | X=20.21 | corridor | Top= 0.22m FCL | 0.0 Pa | 0.00 m/s | 112.607
Duct | 160 mm | CC= 0.30m FCL | 00 | Y=13.15 | CC= 3.00m FFB |  | Extract Air | 11 | 00.04 | CC= 3.00m SSL | 0.0 m\X\B3/h | Edge= 2.92m SSL | NNUK=2.72 m | .015 | 160 | .0000 | X=20.21 | corridor | Top= 0.22m FCL | 0.0 Pa | 0.00 m/s | 128.983

# IfcFlowSegment: SS8310200 (2)
In: 00 Ground floor
Type - Description: Folded Spiral-seam Circ DIN 24145 d 200; ApplicableOccurrence: Circ; PredefinedType: RIGIDSEGMENT
Type - Pset_ManufacturerTypeInformation - ArticleNumber: SS8310200; ModelReference: Folded Spiral-seam Circ DIN 24145 d 200; Manufacturer: DDS
Type - Pset_DuctSegmentTypeCommon - NominalDiameterOrWidth: 200
Material: ML-Folded Spiral-seam Circ DIN 24145 d 200
Pset_DDS - Mounting Height: 3.00 m; Above Sea Level ref. Center: NN=2.80 m; Mtg. Below Ceiling ref Center: CC= 0.30m FCL; Product: Folded Spiral-seam Circ DIN 24145 d 200; Mtg. above Finished Floor ref Center: CC= 3.00m FFB; Manufacturer: DDS; Dimension DN: 200 mm; Mtg. Above Slab ref Center: CC= 3.00m SSL; Iso thickness: iso= 0.000000 mm; Mtg. Below Ceiling ref Top: Top= 0.20m FCL; Model Number: Dra.no: 1; Layer number: 11; Main string number: 00; Width: 200; Project name: OpenBIM; Height: 0; Length: 0; Insulation WSVO: 0; Insulation k-value: 0; Flow: 0.0 m\X\B3/h; Floor number: Storey: 2; Room tekst: corridor; X: X=20.21; Above Sea Level ref. Bottom: NNUK=2.70 m; Flowsegment thickness: x0.0; Product Number: SS8310200; Sub string number: .0000; Room number: 00.04; Mtg. Above Slab ref Bottom: Edge= 2.90m SSL; Building Part: Building: 0; Part number: .015; Medium: Extract Air; Abs. pressure: 0.0 Pa; Velocity: 0.00 m/s
AC_Pset_RenovationAndPhasing - Renovation Status: Existing
Name | Y | Length (mm)
Duct | Y=13.30 | 112.607
Duct | Y=13.64 | 330.587

# IfcFlowSegment: SS8310250 (15)
In: 00 Ground floor
Type - Description: Folded Spiral-seam Circ DIN 24145 d 250; ApplicableOccurrence: Circ; PredefinedType: RIGIDSEGMENT
Type - Pset_ManufacturerTypeInformation - ArticleNumber: SS8310250; ModelReference: Folded Spiral-seam Circ DIN 24145 d 250; Manufacturer: DDS
Type - Pset_DuctSegmentTypeCommon - NominalDiameterOrWidth: 250
Material: ML-Folded Spiral-seam Circ DIN 24145 d 250
Pset_DDS - Above Sea Level ref. Bottom: NNUK=2.68 m; Mounting Height: 3.00 m; Above Sea Level ref. Center: NN=2.80 m; Product: Folded Spiral-seam Circ DIN 24145 d 250; Manufacturer: DDS; Iso thickness: iso= 0.000000 mm; Model Number: Dra.no: 1; Project name: OpenBIM; Insulation WSVO: 0; Insulation k-value: 0; Dimension DN: 250 mm; Floor number: Storey: 2; Width: 250; Flowsegment thickness: x0.0; Building Part: Building: 0; Product Number: SS8310250
AC_Pset_RenovationAndPhasing - Renovation Status: Existing
Name | Pset_FlowSegmentDuctSegment, Length (mm) | Mtg. Below Ceiling ref Center | Velocity | X | Main string number | Mtg. Above Slab ref Bottom | Mtg. above Finished Floor ref Center | Mtg. Above Slab ref Center | Flow | System Name | Abs. pressure | Part number | Medium | Sub string number | Room tekst | Layer number | Room number | Height | Pset_DDS, Length | Y | Mtg. Below Ceiling ref Top | Group
01.0011.01 | 3276.93 | CC= 0.30m FCL | 5.66 m/s | X=18.47 | 01 | Edge= 2.88m SSL | CC= 3.00m FFB | CC= 3.00m SSL | 1000.0 m\X\B3/h | Supply Air | 84.5 Pa | .001 | Supply Air | .0011 | Office | 10 | 001 | 0 | 3 | Y=18.03 | Top= 0.17m FCL | Supply air
01.0011.04 | 1875 | CC= 0.30m FCL | 4.53 m/s | X=17.81 | 01 | Edge= 2.88m SSL | CC= 3.00m FFB | CC= 3.00m SSL | 800.0 m\X\B3/h | Supply Air | 68.3 Pa | .004 | Supply Air | .0011 | Office | 10 | 00.18 | 0 | 2 | Y=14.50 | Top= 0.17m FCL | Supply air
01.0011.04 | 404.268 | CC= 0.30m FCL | 5.66 m/s | X=18.22 | 01 | Edge= 2.88m SSL | CC= 3.00m FFB | CC= 3.00m SSL | 1000.0 m\X\B3/h | Supply Air | 84.5 Pa | .004 | Supply Air | .0011 | Office | 10 | 00.18 | 0 | 0 | Y=14.50 | Top= 0.17m FCL | Supply air
01.0011.06 | 2187.5 | CC= 0.30m FCL | 3.40 m/s | X=15.94 | 01 | Edge= 2.88m SSL | CC= 3.00m FFB | CC= 3.00m SSL | 600.0 m\X\B3/h | Supply Air | 65.8 Pa | .006 | Supply Air | .0011 | Office | 10 | 00.18 | 0 | 2 | Y=14.50 | Top= 0.17m FCL | Supply air
01.0011.08 | 1483.57 | CC= 0.30m FCL | 2.26 m/s | X=13.75 | 01 | Edge= 2.88m SSL | CC= 3.00m FFB | CC= 3.00m SSL | 400.0 m\X\B3/h | Supply Air | 63.9 Pa | .008 | Supply Air | .0011 | Office | 10 | 00.17 | 0 | 1 | Y=14.50 | Top= 0.17m FCL | Supply air
01.0011.12 | 1427.57 | CC= 0.30m FCL | 2.26 m/s | X=12.14 | 01 | Edge= 2.88m SSL | CC= 3.00m FFB | CC= 3.00m SSL | 400.0 m\X\B3/h | Supply Air | 63.9 Pa | .012 | Supply Air | .0011 | Storage | 10 | 00.13 | 0 | 1 | Y=14.47 | Top= 0.17m FCL | Supply air
01.0011.14 | 2152.62 | CC= 0.30m FCL | 2.26 m/s | X=10.78 | 01 | Edge= 2.88m SSL | CC= 3.00m FFB | CC= 3.00m SSL | 400.0 m\X\B3/h | Supply Air | 63.9 Pa | .014 | Supply Air | .0011 | Storage | 10 | 00.13 | 0 | 2 | Y=13.72 | Top= 0.17m FCL | Supply air
01.0011.15 | 1875 | CC= 0.30m FCL | 1.13 m/s | X=8.63 | 01 | Edge= 2.88m SSL | CC= 3.00m FFB | CC= 3.00m SSL | 200.0 m\X\B3/h | Supply Air | 59.0 Pa | .015 | Supply Air | .0011 | Office | 10 | 00.19 | 0 | 2 | Y=13.72 | Top= 0.17m FCL | Supply air
01.0011.17 | 200 | CC= 0.30m FCL | 0.00 m/s | X=6.75 | 01 | Edge= 2.88m SSL | CC= 3.00m FFB | CC= 3.00m SSL | 0.0 m\X\B3/h | Supply Air | 58.8 Pa | .017 | Supply Air | .0011 | Office | 10 | 00.19 | 0 | 1 | Y=13.72 | Top= 0.17m FCL | Supply air
01.0018.07 | 243.537 | CC= 0.18m FCL | 1.22 m/s | X=35.26 | 01 | Edge= 3.00m SSL | CC= 3.12m FFB | CC= 3.12m SSL | 216.0 m\X\B3/h | Supply Air | 225.1 Pa | .007 | Supply Air | .0018 | Office | 10 | 00.23 | 300 | 0 | Y=18.27 | Top= 0.05m FCL | Supply air
01.0018.08 | 2687.7 | CC= 0.18m FCL | 1.22 m/s | X=35.51 | 01 | Edge= 3.00m SSL | CC= 3.12m FFB | CC= 3.12m SSL | 216.0 m\X\B3/h | Supply Air | 225.1 Pa | .008 | Supply Air | .0018 | Office | 10 | 00.23 | 0 | 3 | Y=18.27 | Top= 0.05m FCL | Supply air
01.0018.10 | 161.324 | CC= 0.18m FCL | 0.00 m/s | X=38.19 | 01 | Edge= 3.00m SSL | CC= 3.12m FFB | CC= 3.12m SSL | 0.0 m\X\B3/h | Supply Air | 224.9 Pa | .010 | Supply Air | .0018 | Office | 10 | 00.23 | 0 | 2 | Y=18.27 | Top= 0.05m FCL | Supply air
Duct | 140.516 | CC= 0.30m FCL | 0.00 m/s | X=20.21 | 00 | Edge= 2.88m SSL | CC= 3.00m FFB | CC= 3.00m SSL | 0.0 m\X\B3/h |  | 0.0 Pa | .015 | Extract Air | .0000 | corridor | 11 | 00.04 | 0 | 2 | Y=13.85 | Top= 0.17m FCL
Duct | 862.461 | CC= 0.30m FCL | 0.00 m/s | X=20.21 | 00 | Edge= 2.88m SSL | CC= 3.00m FFB | CC= 3.00m SSL | 0.0 m\X\B3/h |  | 0.0 Pa | .015 | Extract Air | .0000 | Hallway | 11 | 00.02 | 0 | 1 | Y=15.40 | Top= 0.17m FCL
Duct | 691.766 | CC= 0.30m FCL | 0.00 m/s | X=20.21 | 00 | Edge= 2.88m SSL | CC= 3.00m FFB | CC= 3.00m SSL | 0.0 m\X\B3/h |  | 0.0 Pa | .015 | Extract Air | .0000 | corridor | 11 | 00.04 | 0 | 2 | Y=14.54 | Top= 0.17m FCL

# IfcFlowSegment: SS8310315 (10)
In: 00 Ground floor
Type - Description: Folded Spiral-seam Circ DIN 24145 d 315; ApplicableOccurrence: Circ; PredefinedType: RIGIDSEGMENT
Type - Pset_ManufacturerTypeInformation - ArticleNumber: SS8310315; ModelReference: Folded Spiral-seam Circ DIN 24145 d 315; Manufacturer: DDS
Type - Pset_DuctSegmentTypeCommon - NominalDiameterOrWidth: 315
Material: ML-Folded Spiral-seam Circ DIN 24145 d 315; Group: Supply air
Pset_DDS - Dimension DN: 315 mm; Above Sea Level ref. Bottom: NNUK=2.64 m; Mounting Height: 3.00 m; Above Sea Level ref. Center: NN=2.80 m; Mtg. Below Ceiling ref Center: CC= 0.30m FCL; Main string number: 01; Width: 315; Mtg. Above Slab ref Bottom: Edge= 2.84m SSL; Mtg. above Finished Floor ref Center: CC= 3.00m FFB; Manufacturer: DDS; Mtg. Above Slab ref Center: CC= 3.00m SSL; Iso thickness: iso= 0.000000 mm; System Name: Supply Air; Medium: Supply Air; Product Number: SS8310315; Model Number: Dra.no: 1; Layer number: 10; Project name: OpenBIM; Insulation WSVO: 0; Insulation k-value: 0; Floor number: Storey: 2; Product: Folded Spiral-seam Circ DIN 24145 d 315; Flowsegment thickness: x0.0; Mtg. Below Ceiling ref Top: Top= 0.14m FCL; Building Part: Building: 0
AC_Pset_RenovationAndPhasing - Renovation Status: Existing
Name | Part number | Velocity | X | Height | Pset_DDS, Length | Room tekst | Abs. pressure | Y | Sub string number | Room number | Flow | Pset_FlowSegmentDuctSegment, Length (mm)
01.0004.06 | .006 | 7.84 m/s | X=25.17 | 600 | 0 | Hallway | 165.1 Pa | Y=18.32 | .0004 | 00.03 | 2200.0 m\X\B3/h | 314.818
01.0004.08 | .008 | 7.84 m/s | X=24.78 | 0 | 0 | Hallway | 165.1 Pa | Y=18.31 | .0004 | 00.03 | 2200.0 m\X\B3/h | 184.839
01.0004.10 | .010 | 7.84 m/s | X=24.52 | 0 | 4 | Hallway | 165.1 Pa | Y=18.25 | .0004 | 00.03 | 2200.0 m\X\B3/h | 4452.87
01.0004.12 | .012 | 7.13 m/s | X=20.06 | 0 | 2 | Office | 116.6 Pa | Y=18.25 | .0004 | 001 | 2000.0 m\X\B3/h | 1410.73
01.0005.01 | .001 | 2.85 m/s | X=18.19 | 0 | 2 | Office | 109.8 Pa | Y=18.25 | .0005 | 001 | 800.0 m\X\B3/h | 2625
01.0005.01 | .001 | 3.56 m/s | X=18.28 | 0 | 0 | Office | 110.1 Pa | Y=18.25 | .0005 | 001 | 1000.0 m\X\B3/h | 94.2679
01.0005.03 | .003 | 2.14 m/s | X=15.56 | 0 | 2 | Office | 108.7 Pa | Y=18.25 | .0005 | 00.21 | 600.0 m\X\B3/h | 1875
01.0005.05 | .005 | 1.43 m/s | X=13.69 | 0 | 2 | Office | 108.2 Pa | Y=18.25 | .0005 | 00.21 | 400.0 m\X\B3/h | 2905
01.0005.05 | .005 | 0.71 m/s | X=10.78 | 0 | 2 | Office | 107.7 Pa | Y=18.25 | .0005 | 00.20 | 200.0 m\X\B3/h | 1250
01.0005.09 | .009 | 0.00 m/s | X=9.53 | 0 | 1 | Office | 107.7 Pa | Y=18.25 | .0005 | 00.20 | 0.0 m\X\B3/h | 251.241

# IfcFlowSegment: ZZSS (8)
In: 01 First floor
Type - Description: Pipe - shopwindow construction; ApplicableOccurrence: Steel construction; PredefinedType: RIGIDSEGMENT
Type - Pset_ManufacturerTypeInformation - ArticleNumber: ZZSS; ModelReference: Pipe - shopwindow construction; Manufacturer: DDS
Type - Pset_PipeSegmentTypeCommon - NominalDiameter: 15; InnerDiameter: 15; OuterDiameter: 15
Material: ML-Pipe - shopwindow construction
Pset_DDS - Pressure drop: 0 Pa; Drain slope: 1:0; Manufacturer: DDS; Ins thickness: ins= 0.000000 mm; Room tekst: Office; Room number: 01.17; Product Number: ZZSS; Model Number: Dra.no: 2; Drain slope (%): 10000.0 %; Main string number: 00; Project name: OpenBIM; Length: 0; Insulation WSVO: 0; Insulation k-value: 0; Floor number: Storey: 3; Drain Qww: Qww=0.00 l/s; Dimension DN: 15; Width: 15; Flow (l/h): 0.000000 l/h; Flowsegment thickness: x0.0; Part number: .000; Outside dimension: 15.000000; Sub string number: .0000; Drain slope (\X\B0): 90.0\X\B0; Temperature: 0.00 \X\B0C; Drain DU: DU=0.00 l/s; Building Part: Building: 0; Peak flow (l/s): 0.00 l/s; Flow (l/s): 0.00 l/s; Abs. pressure: 0.0 Pa; Velocity: 0.00 m/s; Product: Pipe - shopwindow construction
AC_Pset_RenovationAndPhasing - Renovation Status: Existing
Name | Mtg. above Finished Floor ref Center | Mtg. Below Ceiling ref Center | Above Sea Level ref. Bottom | Y | Mtg. Above Slab ref Bottom | Layer number | X | Mtg. Above Slab ref Center | Mounting Height | Above Sea Level ref. Center | Medium | Mtg. Below Ceiling ref Top | Length (mm)
Pipe | CC= -0.33m FFB | CC= 3.63m FCL | NNUK=3.09 m | Y=12.27 | Edge= -0.34m SSL | 6 | X=5.62 | CC= -0.33m SSL | -0.20 m | NN=3.10 m | Heat return | Top= 3.62m FCL | 349.926
Pipe | CC= -0.31m FFB | CC= 3.61m FCL | NNUK=3.12 m | Y=12.27 | Edge= -0.32m SSL | 6 | X=5.25 | CC= -0.31m SSL | -0.18 m | NN=3.12 m | Heat return | Top= 3.60m FCL | 245
Pipe | CC= -0.04m FFB | CC= 3.34m FCL | NNUK=3.38 m | Y=12.27 | Edge= -0.05m SSL | 6 | X=5.27 | CC= -0.04m SSL | 0.09 m | NN=3.39 m | Heat return | Top= 3.33m FCL | 65.9134
Pipe | CC= -0.02m FFB | CC= 3.32m FCL | NNUK=3.41 m | Y=12.27 | Edge= -0.03m SSL | 6 | X=5.36 | CC= -0.02m SSL | 0.11 m | NN=3.41 m | Heat return | Top= 3.31m FCL | 7.5
