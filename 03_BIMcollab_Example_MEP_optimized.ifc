Properties of the parts of a building model (IFC2X3), part 10 of 14

# IfcFlowSegment: SS091209004 (252)
Name | In | Material | Pset_FlowSegmentPipeSegment, Length (mm) | Mtg. Above Slab ref Center | Mounting Height | Pressure drop | Above Sea Level ref. Center | Main string number | Ins thickness | Mtg. Above Slab ref Bottom | Y | Mtg. Below Ceiling ref Center | Room tekst | Model Number | Layer number | Room number | Pset_DDS, Length | Floor number | Medium | Above Sea Level ref. Bottom | Flow (l/h) | Part number | Sub string number | Temperature | Mtg. Below Ceiling ref Top | Mtg. above Finished Floor ref Center | Peak flow (l/s) | Flow (l/s) | Abs. pressure | Velocity | X
02.0002.00 | 00 Ground floor | ML-Copper pipes length 5 m 18x1 mm | 54.5379 | CC= 2.82m SSL | 2.82 m | 0 Pa | NN=2.62 m | 02 | ins= 0.000000 mm | Edge= 2.82m SSL | Y=17.43 | CC= 0.48m FCL | Hallway | Dra.no: 1 | 188 | 00.03 | 0 | Storey: 2 | Cooling Flow | NNUK=2.62 m | 0.000000 l/h | .000 | .0002 | 0.00 \X\B0C | Top= 0.47m FCL | CC= 2.82m FFB | 0.00 l/s | 0.00 l/s | 0.0 Pa | 0.00 m/s | X=32.17 | Group: Cooling flow; Pset_DDS - System Name: Cooling
02.0002.00 | 00 Ground floor | ML-Copper pipes length 5 m 18x1 mm | 441.177 | CC= 2.90m SSL | 2.90 m | 0 Pa | NN=2.70 m | 02 | ins= 0.000000 mm | Edge= 2.89m SSL | Y=17.45 | CC= 0.40m FCL | Hallway | Dra.no: 1 | 188 | 00.03 | 0 | Storey: 2 | Cooling Flow | NNUK=2.69 m | 0.000000 l/h | .000 | .0002 | 0.00 \X\B0C | Top= 0.39m FCL | CC= 2.90m FFB | 0.00 l/s | 0.00 l/s | 0.0 Pa | 0.00 m/s | X=32.17 | Group: Cooling flow; Pset_DDS - System Name: Cooling
02.0002.00 | 00 Ground floor | ML-Copper pipes length 5 m 18x1 mm | 54.5379 | CC= 2.88m SSL | 2.88 m | 0 Pa | NN=2.68 m | 02 | ins= 0.000000 mm | Edge= 2.87m SSL | Y=17.91 | CC= 0.42m FCL | Hallway | Dra.no: 1 | 188 | 00.03 | 0 | Storey: 2 | Cooling Flow | NNUK=2.67 m | 0.000000 l/h | .000 | .0002 | 0.00 \X\B0C | Top= 0.41m FCL | CC= 2.88m FFB | 0.00 l/s | 0.00 l/s | 0.0 Pa | 0.00 m/s | X=32.17 | Group: Cooling flow; Pset_DDS - System Name: Cooling
02.0002.00 | 00 Ground floor | ML-Copper pipes length 5 m 18x1 mm | 532.943 | CC= 2.80m SSL | 2.80 m | 0 Pa | NN=2.60 m | 02 | ins= 0.000000 mm | Edge= 2.79m SSL | Y=17.94 | CC= 0.50m FCL | Hallway | Dra.no: 1 | 188 | 00.03 | 1 | Storey: 2 | Cooling Flow | NNUK=2.59 m | 0.000000 l/h | .000 | .0002 | 0.00 \X\B0C | Top= 0.49m FCL | CC= 2.80m FFB | 0.00 l/s | 0.00 l/s | 0.0 Pa | 0.00 m/s | X=32.17 | Group: Cooling flow; Pset_DDS - System Name: Cooling
02.0002.00 | 00 Ground floor | ML-Copper pipes length 5 m 18x1 mm | 54.5379 | CC= 2.82m SSL | 2.82 m | 0 Pa | NN=2.62 m | 02 | ins= 0.000000 mm | Edge= 2.82m SSL | Y=18.49 | CC= 0.48m FCL | Hallway | Dra.no: 1 | 188 | 00.03 | 0 | Storey: 2 | Cooling Flow | NNUK=2.62 m | 0.000000 l/h | .000 | .0002 | 0.00 \X\B0C | Top= 0.47m FCL | CC= 2.82m FFB | 0.00 l/s | 0.00 l/s | 0.0 Pa | 0.00 m/s | X=32.17 | Group: Cooling flow; Pset_DDS - System Name: Cooling
02.0002.00 | 00 Ground floor | ML-Copper pipes length 5 m 18x1 mm | 1938.14 | CC= 2.90m SSL | 2.90 m | 0 Pa | NN=2.70 m | 02 | ins= 0.000000 mm | Edge= 2.89m SSL | Y=18.51 | CC= 0.40m FCL | Hallway | Dra.no: 1 | 188 | 00.03 | 2 | Storey: 2 | Cooling Flow | NNUK=2.69 m | 0.000000 l/h | .000 | .0002 | 0.00 \X\B0C | Top= 0.39m FCL | CC= 2.90m FFB | 0.00 l/s | 0.00 l/s | 0.0 Pa | 0.00 m/s | X=32.17 | Group: Cooling flow; Pset_DDS - System Name: Cooling
02.0002.00 | 00 Ground floor | ML-Copper pipes length 5 m 18x1 mm | 3347.15 | CC= 3.02m SSL | 2.90 m | 0 Pa | NN=2.70 m | 02 | ins= 0.000000 mm | Edge= 3.01m SSL | Y=20.48 | CC= 0.28m FCL | FB | Dra.no: 1 | 188 | 00.16 | 3 | Storey: 2 | Cooling Flow | NNUK=2.69 m | 0.000000 l/h | .000 | .0002 | 0.00 \X\B0C | Top= 0.27m FCL | CC= 3.02m FFB | 0.00 l/s | 0.00 l/s | 0.0 Pa | 0.00 m/s | X=32.19 | Group: Cooling flow; Pset_DDS - System Name: Cooling
02.0002.00 | 00 Ground floor | ML-Copper pipes length 5 m 18x1 mm | 23.8179 | CC= 3.02m SSL | 2.90 m | 0 Pa | NN=2.70 m | 02 | ins= 0.000000 mm | Edge= 3.01m SSL | Y=20.48 | CC= 0.28m FCL | Office | Dra.no: 1 | 188 | 00.23 | 0 | Storey: 2 | Cooling Flow | NNUK=2.69 m | 0.000000 l/h | .000 | .0002 | 0.00 \X\B0C | Top= 0.27m FCL | CC= 3.02m FFB | 0.00 l/s | 0.00 l/s | 0.0 Pa | 0.00 m/s | X=35.56 | Group: Cooling flow; Pset_DDS - System Name: Cooling
02.0005.00 | 00 Ground floor | ML-Copper pipes length 5 m 18x1 mm | 10.5869 | CC= 2.79m SSL | 2.79 m | 0 Pa | NN=2.59 m | 02 | ins= 0.000000 mm | Edge= 2.78m SSL | Y=16.85 | CC= 0.51m FCL | Hallway | Dra.no: 1 | 188 | 00.03 | 0 | Storey: 2 | Cooling Flow | NNUK=2.58 m | 0.000000 l/h | .000 | .0005 | 0.00 \X\B0C | Top= 0.50m FCL | CC= 2.79m FFB | 0.00 l/s | 0.00 l/s | 0.0 Pa | 0.00 m/s | X=32.17 | Group: Cooling flow; Pset_DDS - System Name: Cooling
02.0005.02 | 00 Ground floor | ML-Copper pipes length 5 m 18x1 mm | 400.264 | CC= 2.75m SSL | 2.75 m | 0 Pa | NN=2.55 m | 02 | ins= 0.000000 mm | Edge= 2.75m SSL | Y=16.85 | CC= 0.55m FCL | Hallway | Dra.no: 1 | 188 | 00.03 | 0 | Storey: 2 | Cooling Flow | NNUK=2.55 m | 0.000000 l/h | .002 | .0005 | 0.00 \X\B0C | Top= 0.54m FCL | CC= 2.75m FFB | 0.00 l/s | 0.00 l/s | 0.0 Pa | 0.00 m/s | X=32.19 | Group: Cooling flow; Pset_DDS - System Name: Cooling
02.0005.03 | 00 Ground floor | ML-Copper pipes length 5 m 18x1 mm | 300 | CC= 2.78m SSL | 2.78 m | 0 Pa | NN=2.58 m | 02 | ins= 0.000000 mm | Edge= 2.77m SSL | Y=16.85 | CC= 0.52m FCL | Hallway | Dra.no: 1 | 188 | 00.03 | 0 | Storey: 2 | Cooling Flow | NNUK=2.57 m | 0.000000 l/h | .003 | .0005 | 0.00 \X\B0C | Top= 0.52m FCL | CC= 2.78m FFB | 0.00 l/s | 0.00 l/s | 0.0 Pa | 0.00 m/s | X=32.62 | Group: Cooling flow; Pset_DDS - System Name: Cooling
02.0005.04 | 00 Ground floor | ML-Copper pipes length 5 m 18x1 mm | 2901.89 | CC= 3.10m SSL | 3.10 m | 0 Pa | NN=2.90 m | 02 | ins= 0.000000 mm | Edge= 3.09m SSL | Y=16.85 | CC= 0.20m FCL | Hallway | Dra.no: 1 | 188 | 00.03 | 3 | Storey: 2 | Cooling Flow | NNUK=2.89 m | 0.000000 l/h | .004 | .0005 | 0.00 \X\B0C | Top= 0.19m FCL | CC= 3.10m FFB | 0.00 l/s | 0.00 l/s | 0.0 Pa | 0.00 m/s | X=32.64 | Group: Cooling flow; Pset_DDS - System Name: Cooling
02.0006.00 | 00 Ground floor | ML-Copper pipes length 5 m 18x1 mm | 23.8179 | CC= 3.22m SSL | 3.10 m | 0 Pa | NN=2.90 m | 02 | ins= 0.000000 mm | Edge= 3.21m SSL | Y=16.85 | CC= 0.08m FCL | Office | Dra.no: 1 | 188 | 00.23 | 0 | Storey: 2 | Cooling Flow | NNUK=2.89 m | 0.000000 l/h | .000 | .0006 | 0.00 \X\B0C | Top= 0.07m FCL | CC= 3.22m FFB | 0.00 l/s | 0.00 l/s | 0.0 Pa | 0.00 m/s | X=35.56 | Group: Cooling flow; Pset_DDS - System Name: Cooling
03.0005.00 | 00 Ground floor | ML-Copper pipes length 5 m 18x1 mm | 352.948 | CC= 2.80m SSL | 2.80 m | 0 Pa | NN=2.60 m | 03 | ins= 0.000000 mm | Edge= 2.79m SSL | Y=16.78 | CC= 0.50m FCL | Hallway | Dra.no: 1 | 189 | 00.03 | 0 | Storey: 2 | Cooling return | NNUK=2.59 m | 0.000000 l/h | .000 | .0005 | 0.00 \X\B0C | Top= 0.49m FCL | CC= 2.80m FFB | 0.00 l/s | 0.00 l/s | 0.0 Pa | 0.00 m/s | X=32.24 | Group: Cooling return; Pset_DDS - System Name: Cooling
03.0005.02 | 00 Ground floor | ML-Copper pipes length 5 m 18x1 mm | 155.444 | CC= 2.82m SSL | 2.82 m | 0 Pa | NN=2.62 m | 03 | ins= 0.000000 mm | Edge= 2.81m SSL | Y=16.78 | CC= 0.48m FCL | Hallway | Dra.no: 1 | 189 | 00.03 | 0 | Storey: 2 | Cooling return | NNUK=2.62 m | 0.000000 l/h | .002 | .0005 | 0.00 \X\B0C | Top= 0.47m FCL | CC= 2.82m FFB | 0.00 l/s | 0.00 l/s | 0.0 Pa | 0.00 m/s | X=32.62 | Group: Cooling return; Pset_DDS - System Name: Cooling
03.0005.03 | 00 Ground floor | ML-Copper pipes length 5 m 18x1 mm | 2837.84 | CC= 3.00m SSL | 3.00 m | 0 Pa | NN=2.80 m | 03 | ins= 0.000000 mm | Edge= 2.99m SSL | Y=16.78 | CC= 0.30m FCL | Hallway | Dra.no: 1 | 189 | 00.03 | 3 | Storey: 2 | Cooling return | NNUK=2.79 m | 0.000000 l/h | .003 | .0005 | 0.00 \X\B0C | Top= 0.29m FCL | CC= 3.00m FFB | 0.00 l/s | 0.00 l/s | 0.0 Pa | 0.00 m/s | X=32.64 | Group: Cooling return; Pset_DDS - System Name: Cooling
03.0006.00 | 00 Ground floor | ML-Copper pipes length 5 m 18x1 mm | 20.3017 | CC= 3.12m SSL | 3.00 m | 0 Pa | NN=2.80 m | 03 | ins= 0.000000 mm | Edge= 3.11m SSL | Y=16.78 | CC= 0.18m FCL | Office | Dra.no: 1 | 189 | 00.23 | 0 | Storey: 2 | Cooling return | NNUK=2.79 m | 0.000000 l/h | .000 | .0006 | 0.00 \X\B0C | Top= 0.17m FCL | CC= 3.12m FFB | 0.00 l/s | 0.00 l/s | 0.0 Pa | 0.00 m/s | X=35.49 | Group: Cooling return; Pset_DDS - System Name: Cooling
01.0002.00 | 01 First floor | ML-Copper pipes length 5 m 18x1 mm-Pipe insulation 9x18 mm gray insulation thickness 9 mm-9 | 2836 | CC= -0.05m SSL | -0.05 m | 16914 Pa | NN=3.25 m | 01 | ins= 9.000000 mm | Edge= -0.07m SSL | Y=10.94 | CC= 3.35m FCL |  | Dra.no: 2 | 2 |  | 3 | Storey: 3 | Coldwater | NNUK=3.23 m | 3131.999937 l/h | .000 | .0002 | 0.00 \X\B0C | Top= 0.00m FCL | CC= -0.05m FFB | 0.50 l/s | 0.87 l/s | 244406.6 Pa | 2.49 m/s | X=29.36 | Group: Coldwater; Pset_DDS - Insulation product text: Pipe insulation; Insulation product number: ZP150/918; System Name: PW
01.0003.00 | 01 First floor | ML-Copper pipes length 5 m 18x1 mm-Pipe insulation 9x18 mm gray insulation thickness 9 mm-9 | 41.541 | CC= 2.81m SSL | 2.81 m | 0 Pa | NN=6.11 m | 01 | ins= 9.000000 mm | Edge= 2.80m SSL | Y=10.94 | CC= 0.49m FCL |  | Dra.no: 2 | 2 |  | 0 | Storey: 3 | Coldwater | NNUK=6.10 m | 0.000000 l/h | .000 | .0003 | 0.00 \X\B0C | Top= 0.00m FCL | CC= 2.81m FFB | 0.00 l/s | 0.00 l/s | 0.0 Pa | 0.00 m/s | X=29.36 | Group: Coldwater; Pset_DDS - Insulation product text: Pipe insulation; Insulation product number: ZP150/918; System Name: PW
01.0004.00 | 01 First floor | ML-Copper pipes length 5 m 18x1 mm-Pipe insulation 9x18 mm gray insulation thickness 9 mm-9 | 6232.97 | CC= 2.80m SSL | 2.80 m | 33556 Pa | NN=6.10 m | 01 | ins= 9.000000 mm | Edge= 2.78m SSL | Y=10.94 | CC= 0.50m FCL |  | Dra.no: 2 | 2 |  | 6 | Storey: 3 | Coldwater | NNUK=6.08 m | 3131.999937 l/h | .000 | .0004 | 0.00 \X\B0C | Top= 0.00m FCL | CC= 2.80m FFB | 0.50 l/s | 0.87 l/s | 227492.9 Pa | 2.49 m/s | X=29.35 | Group: Coldwater; Pset_DDS - Insulation product text: Pipe insulation; Insulation product number: ZP150/918; System Name: PW
01.0005.00 | 01 First floor | ML-Copper pipes length 5 m 18x1 mm-Pipe insulation 9x18 mm gray insulation thickness 9 mm-9 | 926.418 | CC= 2.67m SSL | 2.80 m | 5704 Pa | NN=6.10 m | 01 | ins= 9.000000 mm | Edge= 2.65m SSL | Y=10.94 | CC= 0.63m FCL | Restaurant | Dra.no: 2 | 2 | 01.03 | 1 | Storey: 3 | Coldwater | NNUK=6.08 m | 2879.999936 l/h | .000 | .0005 | 0.00 \X\B0C | Top= 0.61m FCL | CC= 2.67m FFB | 0.48 l/s | 0.80 l/s | 193936.7 Pa | 2.38 m/s | X=23.10 | Group: Coldwater; Pset_DDS - Insulation product text: Pipe insulation; Insulation product number: ZP150/918; System Name: PW
01.0006.00 | 01 First floor | ML-Copper pipes length 5 m 18x1 mm-Pipe insulation 9x18 mm gray insulation thickness 9 mm-9 | 76.4136 | CC= 2.67m SSL | 2.80 m | 13548 Pa | NN=6.10 m | 01 | ins= 9.000000 mm | Edge= 2.65m SSL | Y=10.94 | CC= 0.63m FCL | Restaurant | Dra.no: 2 | 2 | 01.03 | 0 | Storey: 3 | Coldwater | NNUK=6.08 m | 935.999966 l/h | .000 | .0006 | 0.00 \X\B0C | Top= 0.61m FCL | CC= 2.67m FFB | 0.21 l/s | 0.26 l/s | 136144.2 Pa | 1.55 m/s | X=22.14 | Group: Coldwater; Pset_DDS - Insulation product text: Pipe insulation; Insulation product number: ZP150/918; System Name: PW
01.0011.00 | 01 First floor | ML-Copper pipes length 5 m 18x1 mm-Pipe insulation 9x18 mm gray insulation thickness 9 mm-9 | 1495.78 | CC= 2.67m SSL | 2.80 m | 7875 Pa | NN=6.10 m | 01 | ins= 9.000000 mm | Edge= 2.65m SSL | Y=10.95 | CC= 0.63m FCL | Restaurant | Dra.no: 2 | 2 | 01.03 | 1 | Storey: 3 | Coldwater | NNUK=6.08 m | 1943.999970 l/h | .000 | .0011 | 0.00 \X\B0C | Top= 0.61m FCL | CC= 2.67m FFB | 0.38 l/s | 0.54 l/s | 188232.3 Pa | 1.87 m/s | X=22.16 | Group: Coldwater; Pset_DDS - Insulation product text: Pipe insulation; Insulation product number: ZP150/918; System Name: PW
01.0012.00 | 01 First floor | ML-Copper pipes length 5 m 18x1 mm-Pipe insulation 9x18 mm gray insulation thickness 9 mm-9 | 256.528 | CC= 2.67m SSL | 2.80 m | 1566 Pa | NN=6.10 m | 01 | ins= 9.000000 mm | Edge= 2.65m SSL | Y=12.46 | CC= 0.63m FCL | corridor | Dra.no: 2 | 2 | 01.04 | 0 | Storey: 3 | Coldwater | NNUK=6.08 m | 1691.999969 l/h | .000 | .0012 | 0.00 \X\B0C | Top= 0.61m FCL | CC= 2.67m FFB | 0.34 l/s | 0.47 l/s | 180357.2 Pa | 1.70 m/s | X=22.16 | Group: Coldwater; Pset_DDS - Insulation product text: Pipe insulation; Insulation product number: ZP150/918; System Name: PW
01.0013.00 | 01 First floor | ML-Copper pipes length 5 m 18x1 mm-Pipe insulation 9x18 mm gray insulation thickness 9 mm-9 | 49.25 | CC= 2.67m SSL | 2.80 m | 4225 Pa | NN=6.10 m | 01 | ins= 9.000000 mm | Edge= 2.65m SSL | Y=12.74 | CC= 0.63m FCL | corridor | Dra.no: 2 | 2 | 01.04 | 0 | Storey: 3 | Coldwater | NNUK=6.08 m | 1223.999986 l/h | .000 | .0013 | 0.00 \X\B0C | Top= 0.61m FCL | CC= 2.67m FFB | 0.27 l/s | 0.34 l/s | 178791.0 Pa | 2.00 m/s | X=22.16 | Group: Coldwater; Pset_DDS - Insulation product text: Pipe insulation; Insulation product number: ZP150/918; System Name: PW
02.0001.00 | 01 First floor | ML-Copper pipes length 5 m 18x1 mm-Pipe insulation 9x18 mm gray insulation thickness 9 mm-9 | 317 | CC= 3.20m SSL | 3.20 m | 72106 Pa | NN=6.50 m | 02 | ins= 9.000000 mm | Edge= 3.18m SSL | Y=11.09 | CC= 0.10m FCL |  | Dra.no: 2 | 3 |  | 0 | Storey: 3 | Hotwater | NNUK=6.48 m | 2520.000011 l/h | .000 | .0001 | 64.09 \X\B0C | Top= 0.00m FCL | CC= 3.20m FFB | 0.44 l/s | 0.70 l/s | 276179.0 Pa | 2.20 m/s | X=29.36 | Group: Hotwater; Pset_DDS - Insulation product text: Pipe insulation; Insulation product number: ZP150/918
02.0002.00 | 01 First floor | ML-Copper pipes length 5 m 18x1 mm-Pipe insulation 9x18 mm gray insulation thickness 9 mm-9 | 48.25 | CC= 2.87m SSL | 2.87 m | 37075 Pa | NN=6.17 m | 02 | ins= 9.000000 mm | Edge= 2.85m SSL | Y=11.09 | CC= 0.43m FCL |  | Dra.no: 2 | 3 |  | 0 | Storey: 3 | Hotwater | NNUK=6.15 m | 1260.000005 l/h | .000 | .0002 | 63.38 \X\B0C | Top= 0.00m FCL | CC= 2.87m FFB | 0.27 l/s | 0.35 l/s | 185479.5 Pa | 2.05 m/s | X=29.36 | Group: Hotwater; Pset_DDS - Insulation product text: Pipe insulation; Insulation product number: ZP150/918
03.0001.00 | 01 First floor | ML-Copper pipes length 5 m 18x1 mm-Pipe insulation 9x18 mm gray insulation thickness 9 mm-9 | 242 | CC= 3.20m SSL | 3.20 m | 3343 Pa | NN=6.50 m | 03 | ins= 9.000000 mm | Edge= 3.18m SSL | Y=11.33 | CC= 0.10m FCL |  | Dra.no: 2 | 4 |  | 0 | Storey: 3 | Circulation | NNUK=6.48 m | 282.908085 l/h | .000 | .0001 | 60.29 \X\B0C | Top= 0.00m FCL | CC= 3.20m FFB | 0.00 l/s | 0.08 l/s | 5756.1 Pa | 0.39 m/s | X=29.36 | Group: Circulation; Pset_DDS - Insulation product text: Pipe insulation; Insulation product number: ZP150/918
03.0002.00 | 01 First floor | ML-Copper pipes length 5 m 18x1 mm-Pipe insulation 9x18 mm gray insulation thickness 9 mm-9 | 48.25 | CC= 2.94m SSL | 2.94 m | 2413 Pa | NN=6.24 m | 03 | ins= 9.000000 mm | Edge= 2.93m SSL | Y=11.33 | CC= 0.36m FCL |  | Dra.no: 2 | 4 |  | 0 | Storey: 3 | Circulation | NNUK=6.23 m | 151.334382 l/h | .000 | .0002 | 61.39 \X\B0C | Top= 0.00m FCL | CC= 2.94m FFB | 0.00 l/s | 0.04 l/s | 2413.1 Pa | 0.32 m/s | X=29.36 | Group: Circulation; Pset_DDS - Insulation product text: Pipe insulation; Insulation product number: ZP150/918
02.0001.00 | 02 Second floor | ML-Copper pipes length 5 m 18x1 mm-Pipe insulation 9x18 mm gray insulation thickness 9 mm-9 | 20118.7 | CC= 2.67m SSL | 2.80 m | 72106 Pa | NN=9.60 m | 02 | ins= 9.000000 mm | Edge= 2.65m SSL | Y=11.00 | CC= 0.63m FCL | Installation space | Dra.no: 3 | 3 | 02.04 | 20 | Storey: 4 | Hotwater | NNUK=9.58 m | 2520.000011 l/h | .000 | .0001 | 64.09 \X\B0C | Top= 0.61m FCL | CC= 2.67m FFB | 0.44 l/s | 0.70 l/s | 276179.0 Pa | 2.20 m/s | X=8.72 | Group: Hotwater; Pset_DDS - Insulation product text: Pipe insulation; Insulation product number: ZP150/918
02.0001.10 | 02 Second floor | ML-Copper pipes length 5 m 18x1 mm-Pipe insulation 9x18 mm gray insulation thickness 9 mm-9 | 161.606 | CC= 2.67m SSL | 2.80 m | 72106 Pa | NN=9.60 m | 02 | ins= 9.000000 mm | Edge= 2.65m SSL | Y=11.01 | CC= 0.63m FCL | Unnamed | Dra.no: 3 | 3 | 02.03 | 0 | Storey: 4 | Hotwater | NNUK=9.58 m | 2520.000011 l/h | .010 | .0001 | 64.09 \X\B0C | Top= 0.61m FCL | CC= 2.67m FFB | 0.44 l/s | 0.70 l/s | 276179.0 Pa | 2.20 m/s | X=28.85 | Group: Hotwater; Pset_DDS - Insulation product text: Pipe insulation; Insulation product number: ZP150/918
02.0001.11 | 02 Second floor | ML-Copper pipes length 5 m 18x1 mm-Pipe insulation 9x18 mm gray insulation thickness 9 mm-9 | 338.597 | CC= 2.67m SSL | 2.80 m | 72106 Pa | NN=9.60 m | 02 | ins= 9.000000 mm | Edge= 2.65m SSL | Y=11.09 | CC= 0.63m FCL | Unnamed | Dra.no: 3 | 3 | 02.03 | 0 | Storey: 4 | Hotwater | NNUK=9.58 m | 2520.000011 l/h | .011 | .0001 | 64.09 \X\B0C | Top= 0.61m FCL | CC= 2.67m FFB | 0.44 l/s | 0.70 l/s | 276179.0 Pa | 2.20 m/s | X=29.00 | Group: Hotwater; Pset_DDS - Insulation product text: Pipe insulation; Insulation product number: ZP150/918
02.0001.12 | 02 Second floor | ML-Copper pipes length 5 m 18x1 mm-Pipe insulation 9x18 mm gray insulation thickness 9 mm-9 | 3077.5 | CC= 2.78m SSL | 2.78 m | 72106 Pa | NN=9.58 m | 02 | ins= 9.000000 mm | Edge= 2.76m SSL | Y=11.09 | CC= 0.52m FCL |  | Dra.no: 3 | 3 |  | 3 | Storey: 4 | Hotwater | NNUK=9.56 m | 2520.000011 l/h | .012 | .0001 | 64.09 \X\B0C | Top= 0.00m FCL | CC= 2.78m FFB | 0.44 l/s | 0.70 l/s | 276179.0 Pa | 2.20 m/s | X=29.36 | Group: Hotwater; Pset_DDS - Insulation product text: Pipe insulation; Insulation product number: ZP150/918
03.0001.00 | 02 Second floor | ML-Copper pipes length 5 m 18x1 mm-Pipe insulation 9x18 mm gray insulation thickness 9 mm-9 | 20071.3 | CC= 2.67m SSL | 2.80 m | 3343 Pa | NN=9.60 m | 03 | ins= 9.000000 mm | Edge= 2.65m SSL | Y=11.10 | CC= 0.63m FCL | Installation space | Dra.no: 3 | 4 | 02.04 | 20 | Storey: 4 | Circulation | NNUK=9.58 m | 282.908085 l/h | .000 | .0001 | 60.29 \X\B0C | Top= 0.61m FCL | CC= 2.67m FFB | 0.00 l/s | 0.08 l/s | 5756.1 Pa | 0.39 m/s | X=8.72 | Group: Circulation; Pset_DDS - Insulation product text: Pipe insulation; Insulation product number: ZP150/918
03.0001.15 | 02 Second floor | ML-Copper pipes length 5 m 18x1 mm-Pipe insulation 9x18 mm gray insulation thickness 9 mm-9 | 430.847 | CC= 2.67m SSL | 2.80 m | 3343 Pa | NN=9.60 m | 03 | ins= 9.000000 mm | Edge= 2.65m SSL | Y=11.11 | CC= 0.63m FCL | Unnamed | Dra.no: 3 | 4 | 02.03 | 0 | Storey: 4 | Circulation | NNUK=9.58 m | 282.908085 l/h | .015 | .0001 | 60.29 \X\B0C | Top= 0.61m FCL | CC= 2.67m FFB | 0.00 l/s | 0.08 l/s | 5756.1 Pa | 0.39 m/s | X=28.80 | Group: Circulation; Pset_DDS - Insulation product text: Pipe insulation; Insulation product number: ZP150/918
03.0001.16 | 02 Second floor | ML-Copper pipes length 5 m 18x1 mm-Pipe insulation 9x18 mm gray insulation thickness 9 mm-9 | 153.244 | CC= 2.67m SSL | 2.80 m | 3343 Pa | NN=9.60 m | 03 | ins= 9.000000 mm | Edge= 2.65m SSL | Y=11.33 | CC= 0.63m FCL | Unnamed | Dra.no: 3 | 4 | 02.03 | 0 | Storey: 4 | Circulation | NNUK=9.58 m | 282.908085 l/h | .016 | .0001 | 60.29 \X\B0C | Top= 0.61m FCL | CC= 2.67m FFB | 0.00 l/s | 0.08 l/s | 5756.1 Pa | 0.39 m/s | X=29.19 | Group: Circulation; Pset_DDS - Insulation product text: Pipe insulation; Insulation product number: ZP150/918
03.0001.17 | 02 Second floor | ML-Copper pipes length 5 m 18x1 mm-Pipe insulation 9x18 mm gray insulation thickness 9 mm-9 | 3077.5 | CC= 2.78m SSL | 2.78 m | 3343 Pa | NN=9.58 m | 03 | ins= 9.000000 mm | Edge= 2.76m SSL | Y=11.33 | CC= 0.52m FCL |  | Dra.no: 3 | 4 |  | 3 | Storey: 4 | Circulation | NNUK=9.56 m | 282.908085 l/h | .017 | .0001 | 60.29 \X\B0C | Top= 0.00m FCL | CC= 2.78m FFB | 0.00 l/s | 0.08 l/s | 5756.1 Pa | 0.39 m/s | X=29.36 | Group: Circulation; Pset_DDS - Insulation product text: Pipe insulation; Insulation product number: ZP150/918
Pipe | 00 Ground floor | ML-Copper pipes length 5 m 18x1 mm | 7.5 | CC= 0.23m SSL | 0.11 m | 0 Pa | NN=-0.09 m | 00 | ins= 0.000000 mm | Edge= 0.22m SSL | Y=22.29 | CC= 3.07m FCL | Office | Dra.no: 1 | 5 | 00.23 | 0 | Storey: 2 | Heat flow | NNUK=-0.09 m | 0.000000 l/h | .000 | .0000 | 0.00 \X\B0C | Top= 3.06m FCL | CC= 0.23m FFB | 0.00 l/s | 0.00 l/s | 0.0 Pa | 0.00 m/s | X=35.39
Pipe | 00 Ground floor | ML-Copper pipes length 5 m 18x1 mm | 405.587 | CC= 0.02m SSL | -0.10 m | 0 Pa | NN=-0.30 m | 00 | ins= 0.000000 mm | Edge= 0.01m SSL | Y=21.98 | CC= 3.28m FCL | Office | Dra.no: 1 | 6 | 00.23 | 0 | Storey: 2 | Heat return | NNUK=-0.31 m | 0.000000 l/h | .000 | .0000 | 0.00 \X\B0C | Top= 3.27m FCL | CC= 0.02m FFB | 0.00 l/s | 0.00 l/s | 0.0 Pa | 0.00 m/s | X=35.44
Pipe | 00 Ground floor | ML-Copper pipes length 5 m 18x1 mm | 145 | CC= 0.04m SSL | -0.08 m | 0 Pa | NN=-0.28 m | 00 | ins= 0.000000 mm | Edge= 0.04m SSL | Y=22.41 | CC= 3.26m FCL | Office | Dra.no: 1 | 6 | 00.23 | 0 | Storey: 2 | Heat return | NNUK=-0.28 m | 0.000000 l/h | .000 | .0000 | 0.00 \X\B0C | Top= 3.25m FCL | CC= 0.04m FFB | 0.00 l/s | 0.00 l/s | 0.0 Pa | 0.00 m/s | X=35.44
Pipe | 00 Ground floor | ML-Copper pipes length 5 m 18x1 mm | 67.5792 | CC= 0.21m SSL | 0.09 m | 0 Pa | NN=-0.11 m | 00 | ins= 0.000000 mm | Edge= 0.20m SSL | Y=22.38 | CC= 3.09m FCL | Office | Dra.no: 1 | 6 | 00.23 | 0 | Storey: 2 | Heat return | NNUK=-0.12 m | 0.000000 l/h | .000 | .0000 | 0.00 \X\B0C | Top= 3.08m FCL | CC= 0.21m FFB | 0.00 l/s | 0.00 l/s | 0.0 Pa | 0.00 m/s | X=35.44
Pipe | 00 Ground floor | ML-Copper pipes length 5 m 18x1 mm | 245 | CC= -0.18m SSL | -0.18 m | 0 Pa | NN=-0.38 m | 00 | ins= 0.000000 mm | Edge= -0.18m SSL | Y=22.41 | CC= 3.48m FCL | Storage | Dra.no: 1 | 5 | 00.22 | 0 | Storey: 2 | Heat flow | NNUK=-0.38 m | 0.000000 l/h | .000 | .0000 | 0.00 \X\B0C | Top= 3.47m FCL | CC= -0.18m FFB | 0.00 l/s | 0.00 l/s | 0.0 Pa | 0.00 m/s | X=23.02
Pipe | 00 Ground floor | ML-Copper pipes length 5 m 18x1 mm | 65.9134 | CC= 0.09m SSL | 0.09 m | 0 Pa | NN=-0.11 m | 00 | ins= 0.000000 mm | Edge= 0.08m SSL | Y=22.38 | CC= 3.21m FCL | Storage | Dra.no: 1 | 5 | 00.22 | 0 | Storey: 2 | Heat flow | NNUK=-0.12 m | 0.000000 l/h | .000 | .0000 | 0.00 \X\B0C | Top= 3.20m FCL | CC= 0.09m FFB | 0.00 l/s | 0.00 l/s | 0.0 Pa | 0.00 m/s | X=23.02
Pipe | 00 Ground floor | ML-Copper pipes length 5 m 18x1 mm | 7.5 | CC= 0.11m SSL | 0.11 m | 0 Pa | NN=-0.09 m | 00 | ins= 0.000000 mm | Edge= 0.10m SSL | Y=22.29 | CC= 3.19m FCL | Storage | Dra.no: 1 | 5 | 00.22 | 0 | Storey: 2 | Heat flow | NNUK=-0.09 m | 0.000000 l/h | .000 | .0000 | 0.00 \X\B0C | Top= 3.18m FCL | CC= 0.11m FFB | 0.00 l/s | 0.00 l/s | 0.0 Pa | 0.00 m/s | X=23.02
Pipe | 00 Ground floor | ML-Copper pipes length 5 m 18x1 mm | 393.587 | CC= -0.10m SSL | -0.10 m | 0 Pa | NN=-0.30 m | 00 | ins= 0.000000 mm | Edge= -0.11m SSL | Y=21.99 | CC= 3.40m FCL | Storage | Dra.no: 1 | 6 | 00.22 | 0 | Storey: 2 | Heat return | NNUK=-0.31 m | 0.000000 l/h | .000 | .0000 | 0.00 \X\B0C | Top= 3.39m FCL | CC= -0.10m FFB | 0.00 l/s | 0.00 l/s | 0.0 Pa | 0.00 m/s | X=23.07
Pipe | 00 Ground floor | ML-Copper pipes length 5 m 18x1 mm | 145 | CC= -0.08m SSL | -0.08 m | 0 Pa | NN=-0.28 m | 00 | ins= 0.000000 mm | Edge= -0.08m SSL | Y=22.41 | CC= 3.38m FCL | Storage | Dra.no: 1 | 6 | 00.22 | 0 | Storey: 2 | Heat return | NNUK=-0.28 m | 0.000000 l/h | .000 | .0000 | 0.00 \X\B0C | Top= 3.37m FCL | CC= -0.08m FFB | 0.00 l/s | 0.00 l/s | 0.0 Pa | 0.00 m/s | X=23.07
Pipe | 00 Ground floor | ML-Copper pipes length 5 m 18x1 mm | 65.9134 | CC= 0.09m SSL | 0.09 m | 0 Pa | NN=-0.11 m | 00 | ins= 0.000000 mm | Edge= 0.08m SSL | Y=22.38 | CC= 3.21m FCL | Storage | Dra.no: 1 | 6 | 00.22 | 0 | Storey: 2 | Heat return | NNUK=-0.12 m | 0.000000 l/h | .000 | .0000 | 0.00 \X\B0C | Top= 3.20m FCL | CC= 0.09m FFB | 0.00 l/s | 0.00 l/s | 0.0 Pa | 0.00 m/s | X=23.07
Pipe | 00 Ground floor | ML-Copper pipes length 5 m 18x1 mm | 7.5 | CC= 0.11m SSL | 0.11 m | 0 Pa | NN=-0.09 m | 00 | ins= 0.000000 mm | Edge= 0.10m SSL | Y=22.29 | CC= 3.19m FCL | Storage | Dra.no: 1 | 6 | 00.22 | 0 | Storey: 2 | Heat return | NNUK=-0.09 m | 0.000000 l/h | .000 | .0000 | 0.00 \X\B0C | Top= 3.18m FCL | CC= 0.11m FFB | 0.00 l/s | 0.00 l/s | 0.0 Pa | 0.00 m/s | X=23.07
Pipe | 00 Ground floor | ML-Copper pipes length 5 m 18x1 mm | 277.569 | CC= -0.08m SSL | -0.20 m | 0 Pa | NN=-0.40 m | 00 | ins= 0.000000 mm | Edge= -0.09m SSL | Y=22.10 | CC= 3.38m FCL | Office | Dra.no: 1 | 5 | 00.23 | 0 | Storey: 2 | Heat flow | NNUK=-0.41 m | 0.000000 l/h | .000 | .0000 | 0.00 \X\B0C | Top= 3.37m FCL | CC= -0.08m FFB | 0.00 l/s | 0.00 l/s | 0.0 Pa | 0.00 m/s | X=35.39
Pipe | 00 Ground floor | ML-Copper pipes length 5 m 18x1 mm | 245 | CC= -0.06m SSL | -0.18 m | 0 Pa | NN=-0.38 m | 00 | ins= 0.000000 mm | Edge= -0.06m SSL | Y=22.41 | CC= 3.36m FCL | Office | Dra.no: 1 | 5 | 00.23 | 0 | Storey: 2 | Heat flow | NNUK=-0.38 m | 0.000000 l/h | .000 | .0000 | 0.00 \X\B0C | Top= 3.35m FCL | CC= -0.06m FFB | 0.00 l/s | 0.00 l/s | 0.0 Pa | 0.00 m/s | X=35.39
Pipe | 00 Ground floor | ML-Copper pipes length 5 m 18x1 mm | 67.5792 | CC= 0.21m SSL | 0.09 m | 0 Pa | NN=-0.11 m | 00 | ins= 0.000000 mm | Edge= 0.20m SSL | Y=22.38 | CC= 3.09m FCL | Office | Dra.no: 1 | 5 | 00.23 | 0 | Storey: 2 | Heat flow | NNUK=-0.12 m | 0.000000 l/h | .000 | .0000 | 0.00 \X\B0C | Top= 3.08m FCL | CC= 0.21m FFB | 0.00 l/s | 0.00 l/s | 0.0 Pa | 0.00 m/s | X=35.39
Pipe | 00 Ground floor | ML-Copper pipes length 5 m 18x1 mm | 183.22 | CC= -0.08m SSL | -0.20 m | 0 Pa | NN=-0.40 m | 00 | ins= 0.000000 mm | Edge= -0.09m SSL | Y=7.15 | CC= 3.38m FCL | Director office | Dra.no: 1 | 5 | 00.24 | 0 | Storey: 2 | Heat flow | NNUK=-0.41 m | 0.000000 l/h | .000 | .0000 | 0.00 \X\B0C | Top= 3.37m FCL | CC= -0.08m FFB | 0.00 l/s | 0.00 l/s | 0.0 Pa | 0.00 m/s | X=38.35
Pipe | 00 Ground floor | ML-Copper pipes length 5 m 18x1 mm | 145 | CC= -0.08m SSL | -0.08 m | 0 Pa | NN=-0.28 m | 00 | ins= 0.000000 mm | Edge= -0.09m SSL | Y=22.41 | CC= 3.38m FCL | Office | Dra.no: 1 | 6 | 001 | 0 | Storey: 2 | Heat return | NNUK=-0.28 m | 0.000000 l/h | .000 | .0000 | 0.00 \X\B0C | Top= 3.37m FCL | CC= -0.08m FFB | 0.00 l/s | 0.00 l/s | 0.0 Pa | 0.00 m/s | X=18.57
Pipe | 00 Ground floor | ML-Copper pipes length 5 m 18x1 mm | 245 | CC= -0.06m SSL | -0.18 m | 0 Pa | NN=-0.38 m | 00 | ins= 0.000000 mm | Edge= -0.06m SSL | Y=6.95 | CC= 3.36m FCL | Director office | Dra.no: 1 | 5 | 00.24 | 0 | Storey: 2 | Heat flow | NNUK=-0.38 m | 0.000000 l/h | .000 | .0000 | 0.00 \X\B0C | Top= 3.35m FCL | CC= -0.06m FFB | 0.00 l/s | 0.00 l/s | 0.0 Pa | 0.00 m/s | X=38.35
Pipe | 00 Ground floor | ML-Copper pipes length 5 m 18x1 mm | 393.587 | CC= -0.10m SSL | -0.10 m | 0 Pa | NN=-0.30 m | 00 | ins= 0.000000 mm | Edge= -0.11m SSL | Y=21.99 | CC= 3.40m FCL | Office | Dra.no: 1 | 6 | 001 | 0 | Storey: 2 | Heat return | NNUK=-0.31 m | 0.000000 l/h | .000 | .0000 | 0.00 \X\B0C | Top= 3.39m FCL | CC= -0.10m FFB | 0.00 l/s | 0.00 l/s | 0.0 Pa | 0.00 m/s | X=18.57
Pipe | 00 Ground floor | ML-Copper pipes length 5 m 18x1 mm | 65.9134 | CC= 0.21m SSL | 0.09 m | 0 Pa | NN=-0.11 m | 00 | ins= 0.000000 mm | Edge= 0.20m SSL | Y=6.97 | CC= 3.09m FCL | Director office | Dra.no: 1 | 5 | 00.24 | 0 | Storey: 2 | Heat flow | NNUK=-0.12 m | 0.000000 l/h | .000 | .0000 | 0.00 \X\B0C | Top= 3.08m FCL | CC= 0.21m FFB | 0.00 l/s | 0.00 l/s | 0.0 Pa | 0.00 m/s | X=38.35
Pipe | 00 Ground floor | ML-Copper pipes length 5 m 18x1 mm | 7.5 | CC= 0.11m SSL | 0.11 m | 0 Pa | NN=-0.09 m | 00 | ins= 0.000000 mm | Edge= 0.10m SSL | Y=22.29 | CC= 3.19m FCL | Office | Dra.no: 1 | 5 | 001 | 0 | Storey: 2 | Heat flow | NNUK=-0.09 m | 0.000000 l/h | .000 | .0000 | 0.00 \X\B0C | Top= 3.18m FCL | CC= 0.11m FFB | 0.00 l/s | 0.00 l/s | 0.0 Pa | 0.00 m/s | X=18.52
Pipe | 00 Ground floor | ML-Copper pipes length 5 m 18x1 mm | 7.5 | CC= 0.23m SSL | 0.11 m | 0 Pa | NN=-0.09 m | 00 | ins= 0.000000 mm | Edge= 0.22m SSL | Y=7.06 | CC= 3.07m FCL | Director office | Dra.no: 1 | 5 | 00.24 | 0 | Storey: 2 | Heat flow | NNUK=-0.09 m | 0.000000 l/h | .000 | .0000 | 0.00 \X\B0C | Top= 3.06m FCL | CC= 0.23m FFB | 0.00 l/s | 0.00 l/s | 0.0 Pa | 0.00 m/s | X=38.35
Pipe | 00 Ground floor | ML-Copper pipes length 5 m 18x1 mm | 287.466 | CC= 0.02m SSL | -0.10 m | 0 Pa | NN=-0.30 m | 00 | ins= 0.000000 mm | Edge= 0.01m SSL | Y=7.25 | CC= 3.28m FCL | Director office | Dra.no: 1 | 6 | 00.24 | 0 | Storey: 2 | Heat return | NNUK=-0.31 m | 0.000000 l/h | .000 | .0000 | 0.00 \X\B0C | Top= 3.27m FCL | CC= 0.02m FFB | 0.00 l/s | 0.00 l/s | 0.0 Pa | 0.00 m/s | X=38.30
Pipe | 00 Ground floor | ML-Copper pipes length 5 m 18x1 mm | 145 | CC= 0.04m SSL | -0.08 m | 0 Pa | NN=-0.28 m | 00 | ins= 0.000000 mm | Edge= 0.04m SSL | Y=6.95 | CC= 3.26m FCL | Director office | Dra.no: 1 | 6 | 00.24 | 0 | Storey: 2 | Heat return | NNUK=-0.28 m | 0.000000 l/h | .000 | .0000 | 0.00 \X\B0C | Top= 3.25m FCL | CC= 0.04m FFB | 0.00 l/s | 0.00 l/s | 0.0 Pa | 0.00 m/s | X=38.30
Pipe | 00 Ground floor | ML-Copper pipes length 5 m 18x1 mm | 65.9134 | CC= 0.09m SSL | 0.09 m | 0 Pa | NN=-0.11 m | 00 | ins= 0.000000 mm | Edge= 0.08m SSL | Y=22.38 | CC= 3.21m FCL | Office | Dra.no: 1 | 5 | 001 | 0 | Storey: 2 | Heat flow | NNUK=-0.12 m | 0.000000 l/h | .000 | .0000 | 0.00 \X\B0C | Top= 3.20m FCL | CC= 0.09m FFB | 0.00 l/s | 0.00 l/s | 0.0 Pa | 0.00 m/s | X=18.52
Pipe | 00 Ground floor | ML-Copper pipes length 5 m 18x1 mm | 245 | CC= -0.18m SSL | -0.18 m | 0 Pa | NN=-0.38 m | 00 | ins= 0.000000 mm | Edge= -0.19m SSL | Y=22.41 | CC= 3.48m FCL | Office | Dra.no: 1 | 5 | 001 | 0 | Storey: 2 | Heat flow | NNUK=-0.38 m | 0.000000 l/h | .000 | .0000 | 0.00 \X\B0C | Top= 3.47m FCL | CC= -0.18m FFB | 0.00 l/s | 0.00 l/s | 0.0 Pa | 0.00 m/s | X=18.52
Pipe | 00 Ground floor | ML-Copper pipes length 5 m 18x1 mm | 65.9134 | CC= 0.21m SSL | 0.09 m | 0 Pa | NN=-0.11 m | 00 | ins= 0.000000 mm | Edge= 0.20m SSL | Y=6.97 | CC= 3.09m FCL | Director office | Dra.no: 1 | 6 | 00.24 | 0 | Storey: 2 | Heat return | NNUK=-0.12 m | 0.000000 l/h | .000 | .0000 | 0.00 \X\B0C | Top= 3.08m FCL | CC= 0.21m FFB | 0.00 l/s | 0.00 l/s | 0.0 Pa | 0.00 m/s | X=38.30
Pipe | 00 Ground floor | ML-Copper pipes length 5 m 18x1 mm | 265.569 | CC= -0.20m SSL | -0.20 m | 0 Pa | NN=-0.40 m | 00 | ins= 0.000000 mm | Edge= -0.21m SSL | Y=22.12 | CC= 3.50m FCL | Office | Dra.no: 1 | 5 | 001 | 0 | Storey: 2 | Heat flow | NNUK=-0.41 m | 0.000000 l/h | .000 | .0000 | 0.00 \X\B0C | Top= 3.49m FCL | CC= -0.20m FFB | 0.00 l/s | 0.00 l/s | 0.0 Pa | 0.00 m/s | X=18.52
Pipe | 00 Ground floor | ML-Copper pipes length 5 m 18x1 mm | 7.5 | CC= 0.11m SSL | 0.11 m | 0 Pa | NN=-0.09 m | 00 | ins= 0.000000 mm | Edge= 0.10m SSL | Y=22.29 | CC= 3.19m FCL | Office | Dra.no: 1 | 6 | 001 | 0 | Storey: 2 | Heat return | NNUK=-0.09 m | 0.000000 l/h | .000 | .0000 | 0.00 \X\B0C | Top= 3.18m FCL | CC= 0.11m FFB | 0.00 l/s | 0.00 l/s | 0.0 Pa | 0.00 m/s | X=20.82
Pipe | 00 Ground floor | ML-Copper pipes length 5 m 18x1 mm | 7.5 | CC= 0.23m SSL | 0.11 m | 0 Pa | NN=-0.09 m | 00 | ins= 0.000000 mm | Edge= 0.22m SSL | Y=7.06 | CC= 3.07m FCL | Director office | Dra.no: 1 | 6 | 00.24 | 0 | Storey: 2 | Heat return | NNUK=-0.09 m | 0.000000 l/h | .000 | .0000 | 0.00 \X\B0C | Top= 3.06m FCL | CC= 0.23m FFB | 0.00 l/s | 0.00 l/s | 0.0 Pa | 0.00 m/s | X=38.30
Pipe | 00 Ground floor | ML-Copper pipes length 5 m 18x1 mm | 65.9134 | CC= 0.09m SSL | 0.09 m | 0 Pa | NN=-0.11 m | 00 | ins= 0.000000 mm | Edge= 0.08m SSL | Y=22.38 | CC= 3.21m FCL | Office | Dra.no: 1 | 6 | 001 | 0 | Storey: 2 | Heat return | NNUK=-0.12 m | 0.000000 l/h | .000 | .0000 | 0.00 \X\B0C | Top= 3.20m FCL | CC= 0.09m FFB | 0.00 l/s | 0.00 l/s | 0.0 Pa | 0.00 m/s | X=20.82
Pipe | 00 Ground floor | ML-Copper pipes length 5 m 18x1 mm | 265.569 | CC= -0.20m SSL | -0.20 m | 0 Pa | NN=-0.40 m | 00 | ins= 0.000000 mm | Edge= -0.21m SSL | Y=22.12 | CC= 3.50m FCL | Office | Dra.no: 1 | 5 | 001 | 0 | Storey: 2 | Heat flow | NNUK=-0.41 m | 0.000000 l/h | .000 | .0000 | 0.00 \X\B0C | Top= 3.49m FCL | CC= -0.20m FFB | 0.00 l/s | 0.00 l/s | 0.0 Pa | 0.00 m/s | X=20.77
Pipe | 00 Ground floor | ML-Copper pipes length 5 m 18x1 mm | 145 | CC= -0.08m SSL | -0.08 m | 0 Pa | NN=-0.28 m | 00 | ins= 0.000000 mm | Edge= -0.08m SSL | Y=22.41 | CC= 3.38m FCL | Office | Dra.no: 1 | 6 | 001 | 0 | Storey: 2 | Heat return | NNUK=-0.28 m | 0.000000 l/h | .000 | .0000 | 0.00 \X\B0C | Top= 3.37m FCL | CC= -0.08m FFB | 0.00 l/s | 0.00 l/s | 0.0 Pa | 0.00 m/s | X=20.82
Pipe | 00 Ground floor | ML-Copper pipes length 5 m 18x1 mm | 393.587 | CC= -0.10m SSL | -0.10 m | 0 Pa | NN=-0.30 m | 00 | ins= 0.000000 mm | Edge= -0.11m SSL | Y=21.99 | CC= 3.40m FCL | Office | Dra.no: 1 | 6 | 001 | 0 | Storey: 2 | Heat return | NNUK=-0.31 m | 0.000000 l/h | .000 | .0000 | 0.00 \X\B0C | Top= 3.39m FCL | CC= -0.10m FFB | 0.00 l/s | 0.00 l/s | 0.0 Pa | 0.00 m/s | X=20.82
Pipe | 00 Ground floor | ML-Copper pipes length 5 m 18x1 mm | 7.5 | CC= 0.11m SSL | 0.11 m | 0 Pa | NN=-0.09 m | 00 | ins= 0.000000 mm | Edge= 0.10m SSL | Y=22.29 | CC= 3.19m FCL | Office | Dra.no: 1 | 5 | 001 | 0 | Storey: 2 | Heat flow | NNUK=-0.09 m | 0.000000 l/h | .000 | .0000 | 0.00 \X\B0C | Top= 3.18m FCL | CC= 0.11m FFB | 0.00 l/s | 0.00 l/s | 0.0 Pa | 0.00 m/s | X=20.77
Pipe | 00 Ground floor | ML-Copper pipes length 5 m 18x1 mm | 245 | CC= -0.18m SSL | -0.18 m | 0 Pa | NN=-0.38 m | 00 | ins= 0.000000 mm | Edge= -0.18m SSL | Y=22.41 | CC= 3.48m FCL | Office | Dra.no: 1 | 5 | 001 | 0 | Storey: 2 | Heat flow | NNUK=-0.38 m | 0.000000 l/h | .000 | .0000 | 0.00 \X\B0C | Top= 3.47m FCL | CC= -0.18m FFB | 0.00 l/s | 0.00 l/s | 0.0 Pa | 0.00 m/s | X=20.77
Pipe | 00 Ground floor | ML-Copper pipes length 5 m 18x1 mm | 65.9134 | CC= 0.09m SSL | 0.09 m | 0 Pa | NN=-0.11 m | 00 | ins= 0.000000 mm | Edge= 0.08m SSL | Y=22.38 | CC= 3.21m FCL | Office | Dra.no: 1 | 5 | 001 | 0 | Storey: 2 | Heat flow | NNUK=-0.12 m | 0.000000 l/h | .000 | .0000 | 0.00 \X\B0C | Top= 3.20m FCL | CC= 0.09m FFB | 0.00 l/s | 0.00 l/s | 0.0 Pa | 0.00 m/s | X=20.77
Pipe | 00 Ground floor | ML-Copper pipes length 5 m 18x1 mm | 7.5 | CC= 0.23m SSL | 0.11 m | 0 Pa | NN=-0.09 m | 00 | ins= 0.000000 mm | Edge= 0.22m SSL | Y=22.29 | CC= 3.07m FCL | Office | Dra.no: 1 | 6 | 00.23 | 0 | Storey: 2 | Heat return | NNUK=-0.09 m | 0.000000 l/h | .000 | .0000 | 0.00 \X\B0C | Top= 3.06m FCL | CC= 0.23m FFB | 0.00 l/s | 0.00 l/s | 0.0 Pa | 0.00 m/s | X=35.44
Pipe | 00 Ground floor | ML-Copper pipes length 5 m 18x1 mm | 277.569 | CC= -0.08m SSL | -0.20 m | 0 Pa | NN=-0.40 m | 00 | ins= 0.000000 mm | Edge= -0.09m SSL | Y=22.10 | CC= 3.38m FCL | Office | Dra.no: 1 | 5 | 00.23 | 0 | Storey: 2 | Heat flow | NNUK=-0.41 m | 0.000000 l/h | .000 | .0000 | 0.00 \X\B0C | Top= 3.37m FCL | CC= -0.08m FFB | 0.00 l/s | 0.00 l/s | 0.0 Pa | 0.00 m/s | X=37.95
Pipe | 00 Ground floor | ML-Copper pipes length 5 m 18x1 mm | 245 | CC= -0.06m SSL | -0.18 m | 0 Pa | NN=-0.38 m | 00 | ins= 0.000000 mm | Edge= -0.06m SSL | Y=22.41 | CC= 3.36m FCL | Office | Dra.no: 1 | 5 | 00.23 | 0 | Storey: 2 | Heat flow | NNUK=-0.38 m | 0.000000 l/h | .000 | .0000 | 0.00 \X\B0C | Top= 3.35m FCL | CC= -0.06m FFB | 0.00 l/s | 0.00 l/s | 0.0 Pa | 0.00 m/s | X=37.95
Pipe | 00 Ground floor | ML-Copper pipes length 5 m 18x1 mm | 67.5792 | CC= 0.21m SSL | 0.09 m | 0 Pa | NN=-0.11 m | 00 | ins= 0.000000 mm | Edge= 0.20m SSL | Y=22.38 | CC= 3.09m FCL | Office | Dra.no: 1 | 5 | 00.23 | 0 | Storey: 2 | Heat flow | NNUK=-0.12 m | 0.000000 l/h | .000 | .0000 | 0.00 \X\B0C | Top= 3.08m FCL | CC= 0.21m FFB | 0.00 l/s | 0.00 l/s | 0.0 Pa | 0.00 m/s | X=37.95
Pipe | 00 Ground floor | ML-Copper pipes length 5 m 18x1 mm | 7.5 | CC= 0.23m SSL | 0.11 m | 0 Pa | NN=-0.09 m | 00 | ins= 0.000000 mm | Edge= 0.22m SSL | Y=22.29 | CC= 3.07m FCL | Office | Dra.no: 1 | 5 | 00.23 | 0 | Storey: 2 | Heat flow | NNUK=-0.09 m | 0.000000 l/h | .000 | .0000 | 0.00 \X\B0C | Top= 3.06m FCL | CC= 0.23m FFB | 0.00 l/s | 0.00 l/s | 0.0 Pa | 0.00 m/s | X=37.95
Pipe | 00 Ground floor | ML-Copper pipes length 5 m 18x1 mm | 405.587 | CC= 0.02m SSL | -0.10 m | 0 Pa | NN=-0.30 m | 00 | ins= 0.000000 mm | Edge= 0.01m SSL | Y=21.98 | CC= 3.28m FCL | Office | Dra.no: 1 | 6 | 00.23 | 0 | Storey: 2 | Heat return | NNUK=-0.31 m | 0.000000 l/h | .000 | .0000 | 0.00 \X\B0C | Top= 3.27m FCL | CC= 0.02m FFB | 0.00 l/s | 0.00 l/s | 0.0 Pa | 0.00 m/s | X=38.00
Pipe | 00 Ground floor | ML-Copper pipes length 5 m 18x1 mm | 145 | CC= 0.04m SSL | -0.08 m | 0 Pa | NN=-0.28 m | 00 | ins= 0.000000 mm | Edge= 0.04m SSL | Y=22.41 | CC= 3.26m FCL | Office | Dra.no: 1 | 6 | 00.23 | 0 | Storey: 2 | Heat return | NNUK=-0.28 m | 0.000000 l/h | .000 | .0000 | 0.00 \X\B0C | Top= 3.25m FCL | CC= 0.04m FFB | 0.00 l/s | 0.00 l/s | 0.0 Pa | 0.00 m/s | X=38.00
Pipe | 00 Ground floor | ML-Copper pipes length 5 m 18x1 mm | 67.5792 | CC= 0.21m SSL | 0.09 m | 0 Pa | NN=-0.11 m | 00 | ins= 0.000000 mm | Edge= 0.20m SSL | Y=22.38 | CC= 3.09m FCL | Office | Dra.no: 1 | 6 | 00.23 | 0 | Storey: 2 | Heat return | NNUK=-0.12 m | 0.000000 l/h | .000 | .0000 | 0.00 \X\B0C | Top= 3.08m FCL | CC= 0.21m FFB | 0.00 l/s | 0.00 l/s | 0.0 Pa | 0.00 m/s | X=38.00
Pipe | 00 Ground floor | ML-Copper pipes length 5 m 18x1 mm | 7.5 | CC= 0.23m SSL | 0.11 m | 0 Pa | NN=-0.09 m | 00 | ins= 0.000000 mm | Edge= 0.22m SSL | Y=22.29 | CC= 3.07m FCL | Office | Dra.no: 1 | 6 | 00.23 | 0 | Storey: 2 | Heat return | NNUK=-0.09 m | 0.000000 l/h | .000 | .0000 | 0.00 \X\B0C | Top= 3.06m FCL | CC= 0.23m FFB | 0.00 l/s | 0.00 l/s | 0.0 Pa | 0.00 m/s | X=38.00
Pipe | 00 Ground floor | ML-Copper pipes length 5 m 18x1 mm | 199.909 | CC= -0.08m SSL | -0.20 m | 0 Pa | NN=-0.40 m | 00 | ins= 0.000000 mm | Edge= -0.09m SSL | Y=18.48 | CC= 3.38m FCL | Office | Dra.no: 1 | 5 | 00.23 | 0 | Storey: 2 | Heat flow | NNUK=-0.41 m | 0.000000 l/h | .000 | .0000 | 0.00 \X\B0C | Top= 3.37m FCL | CC= -0.08m FFB | 0.00 l/s | 0.00 l/s | 0.0 Pa | 0.00 m/s | X=40.66
Pipe | 00 Ground floor | ML-Copper pipes length 5 m 18x1 mm | 245 | CC= -0.06m SSL | -0.18 m | 0 Pa | NN=-0.38 m | 00 | ins= 0.000000 mm | Edge= -0.06m SSL | Y=18.48 | CC= 3.36m FCL | Office | Dra.no: 1 | 5 | 00.23 | 0 | Storey: 2 | Heat flow | NNUK=-0.38 m | 0.000000 l/h | .000 | .0000 | 0.00 \X\B0C | Top= 3.35m FCL | CC= -0.06m FFB | 0.00 l/s | 0.00 l/s | 0.0 Pa | 0.00 m/s | X=40.88
Pipe | 00 Ground floor | ML-Copper pipes length 5 m 18x1 mm | 67.5792 | CC= 0.21m SSL | 0.09 m | 0 Pa | NN=-0.11 m | 00 | ins= 0.000000 mm | Edge= 0.20m SSL | Y=18.48 | CC= 3.09m FCL | Office | Dra.no: 1 | 5 | 00.23 | 0 | Storey: 2 | Heat flow | NNUK=-0.12 m | 0.000000 l/h | .000 | .0000 | 0.00 \X\B0C | Top= 3.08m FCL | CC= 0.21m FFB | 0.00 l/s | 0.00 l/s | 0.0 Pa | 0.00 m/s | X=40.86
Pipe | 00 Ground floor | ML-Copper pipes length 5 m 18x1 mm | 7.5 | CC= 0.23m SSL | 0.11 m | 0 Pa | NN=-0.09 m | 00 | ins= 0.000000 mm | Edge= 0.22m SSL | Y=18.48 | CC= 3.07m FCL | Office | Dra.no: 1 | 5 | 00.23 | 0 | Storey: 2 | Heat flow | NNUK=-0.09 m | 0.000000 l/h | .000 | .0000 | 0.00 \X\B0C | Top= 3.06m FCL | CC= 0.23m FFB | 0.00 l/s | 0.00 l/s | 0.0 Pa | 0.00 m/s | X=40.77
Pipe | 00 Ground floor | ML-Copper pipes length 5 m 18x1 mm | 307.084 | CC= 0.02m SSL | -0.10 m | 0 Pa | NN=-0.30 m | 00 | ins= 0.000000 mm | Edge= 0.01m SSL | Y=18.43 | CC= 3.28m FCL | Office | Dra.no: 1 | 6 | 00.23 | 0 | Storey: 2 | Heat return | NNUK=-0.31 m | 0.000000 l/h | .000 | .0000 | 0.00 \X\B0C | Top= 3.27m FCL | CC= 0.02m FFB | 0.00 l/s | 0.00 l/s | 0.0 Pa | 0.00 m/s | X=40.55
Pipe | 00 Ground floor | ML-Copper pipes length 5 m 18x1 mm | 7.5 | CC= 0.11m SSL | 0.11 m | 0 Pa | NN=-0.09 m | 00 | ins= 0.000000 mm | Edge= 0.10m SSL | Y=22.29 | CC= 3.19m FCL | Office | Dra.no: 1 | 6 | 001 | 0 | Storey: 2 | Heat return | NNUK=-0.09 m | 0.000000 l/h | .000 | .0000 | 0.00 \X\B0C | Top= 3.18m FCL | CC= 0.11m FFB | 0.00 l/s | 0.00 l/s | 0.0 Pa | 0.00 m/s | X=18.57
Pipe | 00 Ground floor | ML-Copper pipes length 5 m 18x1 mm | 145 | CC= 0.04m SSL | -0.08 m | 0 Pa | NN=-0.28 m | 00 | ins= 0.000000 mm | Edge= 0.04m SSL | Y=18.43 | CC= 3.26m FCL | Office | Dra.no: 1 | 6 | 00.23 | 0 | Storey: 2 | Heat return | NNUK=-0.28 m | 0.000000 l/h | .000 | .0000 | 0.00 \X\B0C | Top= 3.25m FCL | CC= 0.04m FFB | 0.00 l/s | 0.00 l/s | 0.0 Pa | 0.00 m/s | X=40.88
Pipe | 00 Ground floor | ML-Copper pipes length 5 m 18x1 mm | 67.5792 | CC= 0.21m SSL | 0.09 m | 0 Pa | NN=-0.11 m | 00 | ins= 0.000000 mm | Edge= 0.20m SSL | Y=18.43 | CC= 3.09m FCL | Office | Dra.no: 1 | 6 | 00.23 | 0 | Storey: 2 | Heat return | NNUK=-0.12 m | 0.000000 l/h | .000 | .0000 | 0.00 \X\B0C | Top= 3.08m FCL | CC= 0.21m FFB | 0.00 l/s | 0.00 l/s | 0.0 Pa | 0.00 m/s | X=40.86
Pipe | 00 Ground floor | ML-Copper pipes length 5 m 18x1 mm | 65.9134 | CC= 0.09m SSL | 0.09 m | 0 Pa | NN=-0.11 m | 00 | ins= 0.000000 mm | Edge= 0.08m SSL | Y=22.38 | CC= 3.21m FCL | Office | Dra.no: 1 | 6 | 001 | 0 | Storey: 2 | Heat return | NNUK=-0.12 m | 0.000000 l/h | .000 | .0000 | 0.00 \X\B0C | Top= 3.20m FCL | CC= 0.09m FFB | 0.00 l/s | 0.00 l/s | 0.0 Pa | 0.00 m/s | X=18.57
Pipe | 00 Ground floor | ML-Copper pipes length 5 m 18x1 mm | 7.5 | CC= 0.23m SSL | 0.11 m | 0 Pa | NN=-0.09 m | 00 | ins= 0.000000 mm | Edge= 0.22m SSL | Y=18.43 | CC= 3.07m FCL | Office | Dra.no: 1 | 6 | 00.23 | 0 | Storey: 2 | Heat return | NNUK=-0.09 m | 0.000000 l/h | .000 | .0000 | 0.00 \X\B0C | Top= 3.06m FCL | CC= 0.23m FFB | 0.00 l/s | 0.00 l/s | 0.0 Pa | 0.00 m/s | X=40.77
Pipe | 00 Ground floor | ML-Copper pipes length 5 m 18x1 mm | 65.9134 | CC= 0.09m SSL | 0.09 m | 0 Pa | NN=-0.11 m | 00 | ins= 0.000000 mm | Edge= 0.08m SSL | Y=22.38 | CC= 3.21m FCL | Office | Dra.no: 1 | 6 | 00.20 | 0 | Storey: 2 | Heat return | NNUK=-0.12 m | 0.000000 l/h | .000 | .0000 | 0.00 \X\B0C | Top= 3.20m FCL | CC= 0.09m FFB | 0.00 l/s | 0.00 l/s | 0.0 Pa | 0.00 m/s | X=11.82
Pipe | 00 Ground floor | ML-Copper pipes length 5 m 18x1 mm | 145 | CC= -0.08m SSL | -0.08 m | 0 Pa | NN=-0.28 m | 00 | ins= 0.000000 mm | Edge= -0.09m SSL | Y=22.41 | CC= 3.38m FCL | Office | Dra.no: 1 | 6 | 00.20 | 0 | Storey: 2 | Heat return | NNUK=-0.28 m | 0.000000 l/h | .000 | .0000 | 0.00 \X\B0C | Top= 3.37m FCL | CC= -0.08m FFB | 0.00 l/s | 0.00 l/s | 0.0 Pa | 0.00 m/s | X=11.82
Pipe | 00 Ground floor | ML-Copper pipes length 5 m 18x1 mm | 393.587 | CC= -0.10m SSL | -0.10 m | 0 Pa | NN=-0.30 m | 00 | ins= 0.000000 mm | Edge= -0.11m SSL | Y=21.99 | CC= 3.40m FCL | Office | Dra.no: 1 | 6 | 00.20 | 0 | Storey: 2 | Heat return | NNUK=-0.31 m | 0.000000 l/h | .000 | .0000 | 0.00 \X\B0C | Top= 3.39m FCL | CC= -0.10m FFB | 0.00 l/s | 0.00 l/s | 0.0 Pa | 0.00 m/s | X=11.82
Pipe | 00 Ground floor | ML-Copper pipes length 5 m 18x1 mm | 7.5 | CC= 0.11m SSL | 0.11 m | 0 Pa | NN=-0.09 m | 00 | ins= 0.000000 mm | Edge= 0.10m SSL | Y=22.29 | CC= 3.19m FCL | Office | Dra.no: 1 | 5 | 00.20 | 0 | Storey: 2 | Heat flow | NNUK=-0.09 m | 0.000000 l/h | .000 | .0000 | 0.00 \X\B0C | Top= 3.18m FCL | CC= 0.11m FFB | 0.00 l/s | 0.00 l/s | 0.0 Pa | 0.00 m/s | X=11.77
Pipe | 00 Ground floor | ML-Copper pipes length 5 m 18x1 mm | 65.9134 | CC= 0.09m SSL | 0.09 m | 0 Pa | NN=-0.11 m | 00 | ins= 0.000000 mm | Edge= 0.08m SSL | Y=22.38 | CC= 3.21m FCL | Office | Dra.no: 1 | 5 | 00.20 | 0 | Storey: 2 | Heat flow | NNUK=-0.12 m | 0.000000 l/h | .000 | .0000 | 0.00 \X\B0C | Top= 3.20m FCL | CC= 0.09m FFB | 0.00 l/s | 0.00 l/s | 0.0 Pa | 0.00 m/s | X=11.77
Pipe | 00 Ground floor | ML-Copper pipes length 5 m 18x1 mm | 245 | CC= -0.18m SSL | -0.18 m | 0 Pa | NN=-0.38 m | 00 | ins= 0.000000 mm | Edge= -0.19m SSL | Y=22.41 | CC= 3.48m FCL | Office | Dra.no: 1 | 5 | 00.20 | 0 | Storey: 2 | Heat flow | NNUK=-0.38 m | 0.000000 l/h | .000 | .0000 | 0.00 \X\B0C | Top= 3.47m FCL | CC= -0.18m FFB | 0.00 l/s | 0.00 l/s | 0.0 Pa | 0.00 m/s | X=11.77
Pipe | 00 Ground floor | ML-Copper pipes length 5 m 18x1 mm | 265.569 | CC= -0.20m SSL | -0.20 m | 0 Pa | NN=-0.40 m | 00 | ins= 0.000000 mm | Edge= -0.21m SSL | Y=22.12 | CC= 3.50m FCL | Office | Dra.no: 1 | 5 | 00.20 | 0 | Storey: 2 | Heat flow | NNUK=-0.41 m | 0.000000 l/h | .000 | .0000 | 0.00 \X\B0C | Top= 3.49m FCL | CC= -0.20m FFB | 0.00 l/s | 0.00 l/s | 0.0 Pa | 0.00 m/s | X=11.77
Pipe | 00 Ground floor | ML-Copper pipes length 5 m 18x1 mm | 7.5 | CC= 0.23m SSL | 0.11 m | 0 Pa | NN=-0.09 m | 00 | ins= 0.000000 mm | Edge= 0.22m SSL | Y=12.66 | CC= 3.07m FCL | Storage | Dra.no: 1 | 6 | 00.12 | 0 | Storey: 2 | Heat return | NNUK=-0.09 m | 0.000000 l/h | .000 | .0000 | 0.00 \X\B0C | Top= 3.06m FCL | CC= 0.23m FFB | 0.00 l/s | 0.00 l/s | 0.0 Pa | 0.00 m/s | X=40.77
Pipe | 00 Ground floor | ML-Copper pipes length 5 m 18x1 mm | 65.9134 | CC= 0.21m SSL | 0.09 m | 0 Pa | NN=-0.11 m | 00 | ins= 0.000000 mm | Edge= 0.20m SSL | Y=12.66 | CC= 3.09m FCL | Storage | Dra.no: 1 | 6 | 00.12 | 0 | Storey: 2 | Heat return | NNUK=-0.12 m | 0.000000 l/h | .000 | .0000 | 0.00 \X\B0C | Top= 3.08m FCL | CC= 0.21m FFB | 0.00 l/s | 0.00 l/s | 0.0 Pa | 0.00 m/s | X=40.86
Pipe | 00 Ground floor | ML-Copper pipes length 5 m 18x1 mm | 145 | CC= 0.04m SSL | -0.08 m | 0 Pa | NN=-0.28 m | 00 | ins= 0.000000 mm | Edge= 0.04m SSL | Y=12.66 | CC= 3.26m FCL | Storage | Dra.no: 1 | 6 | 00.12 | 0 | Storey: 2 | Heat return | NNUK=-0.28 m | 0.000000 l/h | .000 | .0000 | 0.00 \X\B0C | Top= 3.25m FCL | CC= 0.04m FFB | 0.00 l/s | 0.00 l/s | 0.0 Pa | 0.00 m/s | X=40.88
Pipe | 00 Ground floor | ML-Copper pipes length 5 m 18x1 mm | 307.084 | CC= 0.02m SSL | -0.10 m | 0 Pa | NN=-0.30 m | 00 | ins= 0.000000 mm | Edge= 0.01m SSL | Y=12.66 | CC= 3.28m FCL | Storage | Dra.no: 1 | 6 | 00.12 | 0 | Storey: 2 | Heat return | NNUK=-0.31 m | 0.000000 l/h | .000 | .0000 | 0.00 \X\B0C | Top= 3.27m FCL | CC= 0.02m FFB | 0.00 l/s | 0.00 l/s | 0.0 Pa | 0.00 m/s | X=40.55
Pipe | 00 Ground floor | ML-Copper pipes length 5 m 18x1 mm | 7.5 | CC= 0.23m SSL | 0.11 m | 0 Pa | NN=-0.09 m | 00 | ins= 0.000000 mm | Edge= 0.22m SSL | Y=12.71 | CC= 3.07m FCL | Storage | Dra.no: 1 | 5 | 00.12 | 0 | Storey: 2 | Heat flow | NNUK=-0.09 m | 0.000000 l/h | .000 | .0000 | 0.00 \X\B0C | Top= 3.06m FCL | CC= 0.23m FFB | 0.00 l/s | 0.00 l/s | 0.0 Pa | 0.00 m/s | X=40.77
Pipe | 00 Ground floor | ML-Copper pipes length 5 m 18x1 mm | 65.9134 | CC= 0.21m SSL | 0.09 m | 0 Pa | NN=-0.11 m | 00 | ins= 0.000000 mm | Edge= 0.20m SSL | Y=12.71 | CC= 3.09m FCL | Storage | Dra.no: 1 | 5 | 00.12 | 0 | Storey: 2 | Heat flow | NNUK=-0.12 m | 0.000000 l/h | .000 | .0000 | 0.00 \X\B0C | Top= 3.08m FCL | CC= 0.21m FFB | 0.00 l/s | 0.00 l/s | 0.0 Pa | 0.00 m/s | X=40.86
Pipe | 00 Ground floor | ML-Copper pipes length 5 m 18x1 mm | 245 | CC= -0.06m SSL | -0.18 m | 0 Pa | NN=-0.38 m | 00 | ins= 0.000000 mm | Edge= -0.06m SSL | Y=12.71 | CC= 3.36m FCL | Storage | Dra.no: 1 | 5 | 00.12 | 0 | Storey: 2 | Heat flow | NNUK=-0.38 m | 0.000000 l/h | .000 | .0000 | 0.00 \X\B0C | Top= 3.35m FCL | CC= -0.06m FFB | 0.00 l/s | 0.00 l/s | 0.0 Pa | 0.00 m/s | X=40.88
Pipe | 00 Ground floor | ML-Copper pipes length 5 m 18x1 mm | 199.909 | CC= -0.08m SSL | -0.20 m | 0 Pa | NN=-0.40 m | 00 | ins= 0.000000 mm | Edge= -0.09m SSL | Y=12.71 | CC= 3.38m FCL | Storage | Dra.no: 1 | 5 | 00.12 | 0 | Storey: 2 | Heat flow | NNUK=-0.41 m | 0.000000 l/h | .000 | .0000 | 0.00 \X\B0C | Top= 3.37m FCL | CC= -0.08m FFB | 0.00 l/s | 0.00 l/s | 0.0 Pa | 0.00 m/s | X=40.66
Pipe | 00 Ground floor | ML-Copper pipes length 5 m 18x1 mm | 7.5 | CC= 0.11m SSL | 0.11 m | 0 Pa | NN=-0.09 m | 00 | ins= 0.000000 mm | Edge= 0.10m SSL | Y=21.47 | CC= 3.19m FCL | Staircase | Dra.no: 1 | 6 | 00.05 | 0 | Storey: 2 | Heat return | NNUK=-0.09 m | 0.000000 l/h | .000 | .0000 | 0.00 \X\B0C | Top= 3.18m FCL | CC= 0.11m FFB | 0.00 l/s | 0.00 l/s | 0.0 Pa | 0.00 m/s | X=5.36
Pipe | 00 Ground floor | ML-Copper pipes length 5 m 18x1 mm | 65.9134 | CC= 0.09m SSL | 0.09 m | 0 Pa | NN=-0.11 m | 00 | ins= 0.000000 mm | Edge= 0.08m SSL | Y=21.47 | CC= 3.21m FCL | Staircase | Dra.no: 1 | 6 | 00.05 | 0 | Storey: 2 | Heat return | NNUK=-0.12 m | 0.000000 l/h | .000 | .0000 | 0.00 \X\B0C | Top= 3.20m FCL | CC= 0.09m FFB | 0.00 l/s | 0.00 l/s | 0.0 Pa | 0.00 m/s | X=5.27
Pipe | 00 Ground floor | ML-Copper pipes length 5 m 18x1 mm | 145 | CC= -0.08m SSL | -0.08 m | 0 Pa | NN=-0.28 m | 00 | ins= 0.000000 mm | Edge= -0.09m SSL | Y=21.47 | CC= 3.38m FCL | Staircase | Dra.no: 1 | 6 | 00.05 | 0 | Storey: 2 | Heat return | NNUK=-0.28 m | 0.000000 l/h | .000 | .0000 | 0.00 \X\B0C | Top= 3.37m FCL | CC= -0.08m FFB | 0.00 l/s | 0.00 l/s | 0.0 Pa | 0.00 m/s | X=5.25
Pipe | 00 Ground floor | ML-Copper pipes length 5 m 18x1 mm | 312.326 | CC= -0.10m SSL | -0.10 m | 0 Pa | NN=-0.30 m | 00 | ins= 0.000000 mm | Edge= -0.11m SSL | Y=21.47 | CC= 3.40m FCL | Staircase | Dra.no: 1 | 6 | 00.05 | 0 | Storey: 2 | Heat return | NNUK=-0.31 m | 0.000000 l/h | .000 | .0000 | 0.00 \X\B0C | Top= 3.39m FCL | CC= -0.10m FFB | 0.00 l/s | 0.00 l/s | 0.0 Pa | 0.00 m/s | X=5.58
Pipe | 00 Ground floor | ML-Copper pipes length 5 m 18x1 mm | 7.5 | CC= 0.11m SSL | 0.11 m | 0 Pa | NN=-0.09 m | 00 | ins= 0.000000 mm | Edge= 0.10m SSL | Y=21.42 | CC= 3.19m FCL | Staircase | Dra.no: 1 | 5 | 00.05 | 0 | Storey: 2 | Heat flow | NNUK=-0.09 m | 0.000000 l/h | .000 | .0000 | 0.00 \X\B0C | Top= 3.18m FCL | CC= 0.11m FFB | 0.00 l/s | 0.00 l/s | 0.0 Pa | 0.00 m/s | X=5.36
Pipe | 00 Ground floor | ML-Copper pipes length 5 m 18x1 mm | 65.9134 | CC= 0.09m SSL | 0.09 m | 0 Pa | NN=-0.11 m | 00 | ins= 0.000000 mm | Edge= 0.08m SSL | Y=21.42 | CC= 3.21m FCL | Staircase | Dra.no: 1 | 5 | 00.05 | 0 | Storey: 2 | Heat flow | NNUK=-0.12 m | 0.000000 l/h | .000 | .0000 | 0.00 \X\B0C | Top= 3.20m FCL | CC= 0.09m FFB | 0.00 l/s | 0.00 l/s | 0.0 Pa | 0.00 m/s | X=5.27
Pipe | 00 Ground floor | ML-Copper pipes length 5 m 18x1 mm | 245 | CC= -0.18m SSL | -0.18 m | 0 Pa | NN=-0.38 m | 00 | ins= 0.000000 mm | Edge= -0.19m SSL | Y=21.42 | CC= 3.48m FCL | Staircase | Dra.no: 1 | 5 | 00.05 | 0 | Storey: 2 | Heat flow | NNUK=-0.38 m | 0.000000 l/h | .000 | .0000 | 0.00 \X\B0C | Top= 3.47m FCL | CC= -0.18m FFB | 0.00 l/s | 0.00 l/s | 0.0 Pa | 0.00 m/s | X=5.25
Pipe | 00 Ground floor | ML-Copper pipes length 5 m 18x1 mm | 181.48 | CC= -0.20m SSL | -0.20 m | 0 Pa | NN=-0.40 m | 00 | ins= 0.000000 mm | Edge= -0.21m SSL | Y=21.42 | CC= 3.50m FCL | Staircase | Dra.no: 1 | 5 | 00.05 | 0 | Storey: 2 | Heat flow | NNUK=-0.41 m | 0.000000 l/h | .000 | .0000 | 0.00 \X\B0C | Top= 3.49m FCL | CC= -0.20m FFB | 0.00 l/s | 0.00 l/s | 0.0 Pa | 0.00 m/s | X=5.45
Pipe | 00 Ground floor | ML-Copper pipes length 5 m 18x1 mm | 7.5 | CC= 0.11m SSL | 0.11 m | 0 Pa | NN=-0.09 m | 00 | ins= 0.000000 mm | Edge= 0.10m SSL | Y=22.29 | CC= 3.19m FCL | Staircase | Dra.no: 1 | 6 | 00.05 | 0 | Storey: 2 | Heat return | NNUK=-0.09 m | 0.000000 l/h | .000 | .0000 | 0.00 \X\B0C | Top= 3.18m FCL | CC= 0.11m FFB | 0.00 l/s | 0.00 l/s | 0.0 Pa | 0.00 m/s | X=7.32
Pipe | 00 Ground floor | ML-Copper pipes length 5 m 18x1 mm | 65.9134 | CC= 0.09m SSL | 0.09 m | 0 Pa | NN=-0.11 m | 00 | ins= 0.000000 mm | Edge= 0.08m SSL | Y=22.38 | CC= 3.21m FCL | Staircase | Dra.no: 1 | 6 | 00.05 | 0 | Storey: 2 | Heat return | NNUK=-0.12 m | 0.000000 l/h | .000 | .0000 | 0.00 \X\B0C | Top= 3.20m FCL | CC= 0.09m FFB | 0.00 l/s | 0.00 l/s | 0.0 Pa | 0.00 m/s | X=7.32
Pipe | 00 Ground floor | ML-Copper pipes length 5 m 18x1 mm | 7.5 | CC= 0.11m SSL | 0.11 m | 0 Pa | NN=-0.09 m | 00 | ins= 0.000000 mm | Edge= 0.10m SSL | Y=22.29 | CC= 3.19m FCL | Office | Dra.no: 1 | 6 | 00.21 | 0 | Storey: 2 | Heat return | NNUK=-0.09 m | 0.000000 l/h | .000 | .0000 | 0.00 \X\B0C | Top= 3.18m FCL | CC= 0.11m FFB | 0.00 l/s | 0.00 l/s | 0.0 Pa | 0.00 m/s | X=14.07
Pipe | 00 Ground floor | ML-Copper pipes length 5 m 18x1 mm | 265.569 | CC= -0.20m SSL | -0.20 m | 0 Pa | NN=-0.40 m | 00 | ins= 0.000000 mm | Edge= -0.21m SSL | Y=22.12 | CC= 3.50m FCL | Storage | Dra.no: 1 | 5 | 00.22 | 0 | Storey: 2 | Heat flow | NNUK=-0.41 m | 0.000000 l/h | .000 | .0000 | 0.00 \X\B0C | Top= 3.49m FCL | CC= -0.20m FFB | 0.00 l/s | 0.00 l/s | 0.0 Pa | 0.00 m/s | X=23.02
Pipe | 00 Ground floor | ML-Copper pipes length 5 m 18x1 mm | 65.9134 | CC= 0.09m SSL | 0.09 m | 0 Pa | NN=-0.11 m | 00 | ins= 0.000000 mm | Edge= 0.08m SSL | Y=22.38 | CC= 3.21m FCL | Office | Dra.no: 1 | 6 | 00.21 | 0 | Storey: 2 | Heat return | NNUK=-0.12 m | 0.000000 l/h | .000 | .0000 | 0.00 \X\B0C | Top= 3.20m FCL | CC= 0.09m FFB | 0.00 l/s | 0.00 l/s | 0.0 Pa | 0.00 m/s | X=14.07
Pipe | 00 Ground floor | ML-Copper pipes length 5 m 18x1 mm | 145 | CC= -0.08m SSL | -0.08 m | 0 Pa | NN=-0.28 m | 00 | ins= 0.000000 mm | Edge= -0.09m SSL | Y=22.41 | CC= 3.38m FCL | Office | Dra.no: 1 | 6 | 00.21 | 0 | Storey: 2 | Heat return | NNUK=-0.28 m | 0.000000 l/h | .000 | .0000 | 0.00 \X\B0C | Top= 3.37m FCL | CC= -0.08m FFB | 0.00 l/s | 0.00 l/s | 0.0 Pa | 0.00 m/s | X=14.07
Pipe | 00 Ground floor | ML-Copper pipes length 5 m 18x1 mm | 393.587 | CC= -0.10m SSL | -0.10 m | 0 Pa | NN=-0.30 m | 00 | ins= 0.000000 mm | Edge= -0.11m SSL | Y=21.99 | CC= 3.40m FCL | Office | Dra.no: 1 | 6 | 00.21 | 0 | Storey: 2 | Heat return | NNUK=-0.31 m | 0.000000 l/h | .000 | .0000 | 0.00 \X\B0C | Top= 3.39m FCL | CC= -0.10m FFB | 0.00 l/s | 0.00 l/s | 0.0 Pa | 0.00 m/s | X=14.07
Pipe | 00 Ground floor | ML-Copper pipes length 5 m 18x1 mm | 7.5 | CC= 0.11m SSL | 0.11 m | 0 Pa | NN=-0.09 m | 00 | ins= 0.000000 mm | Edge= 0.10m SSL | Y=22.29 | CC= 3.19m FCL | Office | Dra.no: 1 | 5 | 00.21 | 0 | Storey: 2 | Heat flow | NNUK=-0.09 m | 0.000000 l/h | .000 | .0000 | 0.00 \X\B0C | Top= 3.18m FCL | CC= 0.11m FFB | 0.00 l/s | 0.00 l/s | 0.0 Pa | 0.00 m/s | X=14.02
Pipe | 00 Ground floor | ML-Copper pipes length 5 m 18x1 mm | 65.9134 | CC= 0.09m SSL | 0.09 m | 0 Pa | NN=-0.11 m | 00 | ins= 0.000000 mm | Edge= 0.08m SSL | Y=22.38 | CC= 3.21m FCL | Office | Dra.no: 1 | 5 | 00.21 | 0 | Storey: 2 | Heat flow | NNUK=-0.12 m | 0.000000 l/h | .000 | .0000 | 0.00 \X\B0C | Top= 3.20m FCL | CC= 0.09m FFB | 0.00 l/s | 0.00 l/s | 0.0 Pa | 0.00 m/s | X=14.02
Pipe | 00 Ground floor | ML-Copper pipes length 5 m 18x1 mm | 245 | CC= -0.18m SSL | -0.18 m | 0 Pa | NN=-0.38 m | 00 | ins= 0.000000 mm | Edge= -0.19m SSL | Y=22.41 | CC= 3.48m FCL | Office | Dra.no: 1 | 5 | 00.21 | 0 | Storey: 2 | Heat flow | NNUK=-0.38 m | 0.000000 l/h | .000 | .0000 | 0.00 \X\B0C | Top= 3.47m FCL | CC= -0.18m FFB | 0.00 l/s | 0.00 l/s | 0.0 Pa | 0.00 m/s | X=14.02
Pipe | 00 Ground floor | ML-Copper pipes length 5 m 18x1 mm | 265.569 | CC= -0.20m SSL | -0.20 m | 0 Pa | NN=-0.40 m | 00 | ins= 0.000000 mm | Edge= -0.21m SSL | Y=22.12 | CC= 3.50m FCL | Office | Dra.no: 1 | 5 | 00.21 | 0 | Storey: 2 | Heat flow | NNUK=-0.41 m | 0.000000 l/h | .000 | .0000 | 0.00 \X\B0C | Top= 3.49m FCL | CC= -0.20m FFB | 0.00 l/s | 0.00 l/s | 0.0 Pa | 0.00 m/s | X=14.02
Pipe | 00 Ground floor | ML-Copper pipes length 5 m 18x1 mm | 7.5 | CC= 0.11m SSL | 0.11 m | 0 Pa | NN=-0.09 m | 00 | ins= 0.000000 mm | Edge= 0.10m SSL | Y=22.29 | CC= 3.19m FCL | Office | Dra.no: 1 | 6 | 00.21 | 0 | Storey: 2 | Heat return | NNUK=-0.09 m | 0.000000 l/h | .000 | .0000 | 0.00 \X\B0C | Top= 3.18m FCL | CC= 0.11m FFB | 0.00 l/s | 0.00 l/s | 0.0 Pa | 0.00 m/s | X=16.32
Pipe | 00 Ground floor | ML-Copper pipes length 5 m 18x1 mm | 65.9134 | CC= 0.09m SSL | 0.09 m | 0 Pa | NN=-0.11 m | 00 | ins= 0.000000 mm | Edge= 0.08m SSL | Y=22.38 | CC= 3.21m FCL | Office | Dra.no: 1 | 6 | 00.21 | 0 | Storey: 2 | Heat return | NNUK=-0.12 m | 0.000000 l/h | .000 | .0000 | 0.00 \X\B0C | Top= 3.20m FCL | CC= 0.09m FFB | 0.00 l/s | 0.00 l/s | 0.0 Pa | 0.00 m/s | X=16.32
Pipe | 00 Ground floor | ML-Copper pipes length 5 m 18x1 mm | 145 | CC= -0.08m SSL | -0.08 m | 0 Pa | NN=-0.28 m | 00 | ins= 0.000000 mm | Edge= -0.09m SSL | Y=22.41 | CC= 3.38m FCL | Office | Dra.no: 1 | 6 | 00.21 | 0 | Storey: 2 | Heat return | NNUK=-0.28 m | 0.000000 l/h | .000 | .0000 | 0.00 \X\B0C | Top= 3.37m FCL | CC= -0.08m FFB | 0.00 l/s | 0.00 l/s | 0.0 Pa | 0.00 m/s | X=16.32
Pipe | 00 Ground floor | ML-Copper pipes length 5 m 18x1 mm | 393.587 | CC= -0.10m SSL | -0.10 m | 0 Pa | NN=-0.30 m | 00 | ins= 0.000000 mm | Edge= -0.11m SSL | Y=21.99 | CC= 3.40m FCL | Office | Dra.no: 1 | 6 | 00.21 | 0 | Storey: 2 | Heat return | NNUK=-0.31 m | 0.000000 l/h | .000 | .0000 | 0.00 \X\B0C | Top= 3.39m FCL | CC= -0.10m FFB | 0.00 l/s | 0.00 l/s | 0.0 Pa | 0.00 m/s | X=16.32
Pipe | 00 Ground floor | ML-Copper pipes length 5 m 18x1 mm | 7.5 | CC= 0.11m SSL | 0.11 m | 0 Pa | NN=-0.09 m | 00 | ins= 0.000000 mm | Edge= 0.10m SSL | Y=22.29 | CC= 3.19m FCL | Office | Dra.no: 1 | 5 | 00.21 | 0 | Storey: 2 | Heat flow | NNUK=-0.09 m | 0.000000 l/h | .000 | .0000 | 0.00 \X\B0C | Top= 3.18m FCL | CC= 0.11m FFB | 0.00 l/s | 0.00 l/s | 0.0 Pa | 0.00 m/s | X=16.27
Pipe | 00 Ground floor | ML-Copper pipes length 5 m 18x1 mm | 65.9134 | CC= 0.09m SSL | 0.09 m | 0 Pa | NN=-0.11 m | 00 | ins= 0.000000 mm | Edge= 0.08m SSL | Y=22.38 | CC= 3.21m FCL | Office | Dra.no: 1 | 5 | 00.21 | 0 | Storey: 2 | Heat flow | NNUK=-0.12 m | 0.000000 l/h | .000 | .0000 | 0.00 \X\B0C | Top= 3.20m FCL | CC= 0.09m FFB | 0.00 l/s | 0.00 l/s | 0.0 Pa | 0.00 m/s | X=16.27
Pipe | 00 Ground floor | ML-Copper pipes length 5 m 18x1 mm | 245 | CC= -0.18m SSL | -0.18 m | 0 Pa | NN=-0.38 m | 00 | ins= 0.000000 mm | Edge= -0.19m SSL | Y=22.41 | CC= 3.48m FCL | Office | Dra.no: 1 | 5 | 00.21 | 0 | Storey: 2 | Heat flow | NNUK=-0.38 m | 0.000000 l/h | .000 | .0000 | 0.00 \X\B0C | Top= 3.47m FCL | CC= -0.18m FFB | 0.00 l/s | 0.00 l/s | 0.0 Pa | 0.00 m/s | X=16.27
Pipe | 00 Ground floor | ML-Copper pipes length 5 m 18x1 mm | 265.569 | CC= -0.20m SSL | -0.20 m | 0 Pa | NN=-0.40 m | 00 | ins= 0.000000 mm | Edge= -0.21m SSL | Y=22.12 | CC= 3.50m FCL | Office | Dra.no: 1 | 5 | 00.21 | 0 | Storey: 2 | Heat flow | NNUK=-0.41 m | 0.000000 l/h | .000 | .0000 | 0.00 \X\B0C | Top= 3.49m FCL | CC= -0.20m FFB | 0.00 l/s | 0.00 l/s | 0.0 Pa | 0.00 m/s | X=16.27
Pipe | 00 Ground floor | ML-Copper pipes length 5 m 18x1 mm | 7.5 | CC= 0.11m SSL | 0.11 m | 0 Pa | NN=-0.09 m | 00 | ins= 0.000000 mm | Edge= 0.10m SSL | Y=22.29 | CC= 3.19m FCL | Office | Dra.no: 1 | 6 | 00.20 | 0 | Storey: 2 | Heat return | NNUK=-0.09 m | 0.000000 l/h | .000 | .0000 | 0.00 \X\B0C | Top= 3.18m FCL | CC= 0.11m FFB | 0.00 l/s | 0.00 l/s | 0.0 Pa | 0.00 m/s | X=9.57
Pipe | 00 Ground floor | ML-Copper pipes length 5 m 18x1 mm | 65.9134 | CC= 0.09m SSL | 0.09 m | 0 Pa | NN=-0.11 m | 00 | ins= 0.000000 mm | Edge= 0.08m SSL | Y=22.38 | CC= 3.21m FCL | Office | Dra.no: 1 | 6 | 00.20 | 0 | Storey: 2 | Heat return | NNUK=-0.12 m | 0.000000 l/h | .000 | .0000 | 0.00 \X\B0C | Top= 3.20m FCL | CC= 0.09m FFB | 0.00 l/s | 0.00 l/s | 0.0 Pa | 0.00 m/s | X=9.57
Pipe | 00 Ground floor | ML-Copper pipes length 5 m 18x1 mm | 145 | CC= -0.08m SSL | -0.08 m | 0 Pa | NN=-0.28 m | 00 | ins= 0.000000 mm | Edge= -0.09m SSL | Y=22.41 | CC= 3.38m FCL | Office | Dra.no: 1 | 6 | 00.20 | 0 | Storey: 2 | Heat return | NNUK=-0.28 m | 0.000000 l/h | .000 | .0000 | 0.00 \X\B0C | Top= 3.37m FCL | CC= -0.08m FFB | 0.00 l/s | 0.00 l/s | 0.0 Pa | 0.00 m/s | X=9.57
Pipe | 00 Ground floor | ML-Copper pipes length 5 m 18x1 mm | 393.587 | CC= -0.10m SSL | -0.10 m | 0 Pa | NN=-0.30 m | 00 | ins= 0.000000 mm | Edge= -0.11m SSL | Y=21.99 | CC= 3.40m FCL | Office | Dra.no: 1 | 6 | 00.20 | 0 | Storey: 2 | Heat return | NNUK=-0.31 m | 0.000000 l/h | .000 | .0000 | 0.00 \X\B0C | Top= 3.39m FCL | CC= -0.10m FFB | 0.00 l/s | 0.00 l/s | 0.0 Pa | 0.00 m/s | X=9.57
Pipe | 00 Ground floor | ML-Copper pipes length 5 m 18x1 mm | 7.5 | CC= 0.11m SSL | 0.11 m | 0 Pa | NN=-0.09 m | 00 | ins= 0.000000 mm | Edge= 0.10m SSL | Y=22.29 | CC= 3.19m FCL | Office | Dra.no: 1 | 5 | 00.20 | 0 | Storey: 2 | Heat flow | NNUK=-0.09 m | 0.000000 l/h | .000 | .0000 | 0.00 \X\B0C | Top= 3.18m FCL | CC= 0.11m FFB | 0.00 l/s | 0.00 l/s | 0.0 Pa | 0.00 m/s | X=9.52
Pipe | 00 Ground floor | ML-Copper pipes length 5 m 18x1 mm | 65.9134 | CC= 0.09m SSL | 0.09 m | 0 Pa | NN=-0.11 m | 00 | ins= 0.000000 mm | Edge= 0.08m SSL | Y=22.38 | CC= 3.21m FCL | Office | Dra.no: 1 | 5 | 00.20 | 0 | Storey: 2 | Heat flow | NNUK=-0.12 m | 0.000000 l/h | .000 | .0000 | 0.00 \X\B0C | Top= 3.20m FCL | CC= 0.09m FFB | 0.00 l/s | 0.00 l/s | 0.0 Pa | 0.00 m/s | X=9.52
