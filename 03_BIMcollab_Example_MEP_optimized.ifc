Properties of the parts of a building model (IFC2X3), part 14 of 14

# IfcFlowSegment: ZZSS (8)
Name | Mtg. above Finished Floor ref Center | Mtg. Below Ceiling ref Center | Above Sea Level ref. Bottom | Y | Mtg. Above Slab ref Bottom | Layer number | X | Mtg. Above Slab ref Center | Mounting Height | Above Sea Level ref. Center | Medium | Mtg. Below Ceiling ref Top | Length (mm)
Pipe | CC= -0.02m FFB | CC= 3.32m FCL | NNUK=3.41 m | Y=12.22 | Edge= -0.03m SSL | 5 | X=5.36 | CC= -0.02m SSL | 0.11 m | NN=3.41 m | Heat flow | Top= 3.31m FCL | 7.5
Pipe | CC= -0.04m FFB | CC= 3.34m FCL | NNUK=3.38 m | Y=12.22 | Edge= -0.05m SSL | 5 | X=5.27 | CC= -0.04m SSL | 0.09 m | NN=3.39 m | Heat flow | Top= 3.33m FCL | 65.9134
Pipe | CC= -0.21m FFB | CC= 3.51m FCL | NNUK=3.22 m | Y=12.22 | Edge= -0.22m SSL | 5 | X=5.25 | CC= -0.21m SSL | -0.08 m | NN=3.22 m | Heat flow | Top= 3.50m FCL | 145
Pipe | CC= -0.23m FFB | CC= 3.53m FCL | NNUK=3.19 m | Y=12.22 | Edge= -0.24m SSL | 5 | X=5.48 | CC= -0.23m SSL | -0.10 m | NN=3.20 m | Heat flow | Top= 3.52m FCL | 210.821

# IfcFlowTerminal: 60-516-09000 (24)
Type - Description: 3M socket Cat 6 2x RJ45 pearl white flush mounted; ApplicableOccurrence: Data network; PredefinedType: COMMUNICATIONSOUTLET
Type - Pset_ManufacturerTypeInformation - ArticleNumber: 60-516-09000; ModelReference: 3M socket Cat 6 2x RJ45 pearl white flush mounted; Manufacturer: 3M
Type - Pset_OutletTypeCommon - IsPluggableOutlet: yes
Type - Pset_ElectricalDeviceCommon - HasProtectiveEarth: no
Material: IFC Building Material
Pset_DDS - Voltage loss: 100.0%; Product: 3M socket Cat 6 2x RJ45 pearl white flush mounted; Product Number: 60-516-09000; Room tekst: Office; Layer number: 30; Project name: OpenBIM; Manufacturer: 3M; Voltage: 0V; Building Part: Building: 0; Cable length to central: 0.000 m
Pset_ElectricalCostData - CostCodeValue: 0-516-09000; Location: NOR; SystemCodeValue: 30; ProductCodeName: NS3420; ProductCodeValue: XG1; CostCodeName: Eldata Kode; SystemCodeName: NS3451
Pset_DistributionFlowElementCommon - Reference: 60-516-09000
AC_Pset_RenovationAndPhasing - Renovation Status: Existing
Name | In | Mounting Height | Mtg. Below Ceiling ref Center | X | Mtg. above Finished Floor ref Center | Mtg. Above Slab ref Center | Above Sea Level ref. Center | Model Number | Room number | Floor number | Y | Mtg. Below Ceiling ref Top | Above Sea Level ref. Bottom | Mtg. Above Slab ref Bottom
LVE2 | 00 Ground floor | 0.40 m | CC= 2.90m FCL | X=17.17 | CC= 0.40m FFB | CC= 0.40m SSL | NN=0.20 m | Dra.no: 1 | 001 | Storey: 2 | Y=22.34 | Top= 2.90m FCL | NNUK=0.20 m | Edge= 0.40m SSL
LVE2 | 00 Ground floor | 0.40 m | CC= 2.90m FCL | X=21.16 | CC= 0.40m FFB | CC= 0.40m SSL | NN=0.20 m | Dra.no: 1 | 001 | Storey: 2 | Y=22.34 | Top= 2.90m FCL | NNUK=0.20 m | Edge= 0.40m SSL
LVE2 | 00 Ground floor | 0.30 m | CC= 3.00m FCL | X=20.85 | CC= 0.30m FFB | CC= 0.30m SSL | NN=0.10 m | Dra.no: 1 | 001 | Storey: 2 | Y=17.13 | Top= 3.00m FCL | NNUK=0.10 m | Edge= 0.30m SSL
LVE2 | 00 Ground floor | 0.30 m | CC= 3.00m FCL | X=18.97 | CC= 0.30m FFB | CC= 0.30m SSL | NN=0.10 m | Dra.no: 1 | 001 | Storey: 2 | Y=17.13 | Top= 3.00m FCL | NNUK=0.10 m | Edge= 0.30m SSL
LVE2 | 00 Ground floor | 0.40 m | CC= 2.90m FCL | X=12.67 | CC= 0.40m FFB | CC= 0.40m SSL | NN=0.20 m | Dra.no: 1 | 00.21 | Storey: 2 | Y=22.34 | Top= 2.90m FCL | NNUK=0.20 m | Edge= 0.40m SSL
LVE2 | 00 Ground floor | 0.40 m | CC= 2.90m FCL | X=16.66 | CC= 0.40m FFB | CC= 0.40m SSL | NN=0.20 m | Dra.no: 1 | 00.21 | Storey: 2 | Y=22.34 | Top= 2.90m FCL | NNUK=0.20 m | Edge= 0.40m SSL
LVE2 | 00 Ground floor | 0.30 m | CC= 3.00m FCL | X=16.35 | CC= 0.30m FFB | CC= 0.30m SSL | NN=0.10 m | Dra.no: 1 | 00.21 | Storey: 2 | Y=17.13 | Top= 3.00m FCL | NNUK=0.10 m | Edge= 0.30m SSL
LVE2 | 00 Ground floor | 0.30 m | CC= 3.00m FCL | X=14.47 | CC= 0.30m FFB | CC= 0.30m SSL | NN=0.10 m | Dra.no: 1 | 00.21 | Storey: 2 | Y=17.13 | Top= 3.00m FCL | NNUK=0.10 m | Edge= 0.30m SSL
LVE2 | 00 Ground floor | 0.40 m | CC= 2.90m FCL | X=8.18 | CC= 0.40m FFB | CC= 0.40m SSL | NN=0.20 m | Dra.no: 1 | 00.20 | Storey: 2 | Y=22.34 | Top= 2.90m FCL | NNUK=0.20 m | Edge= 0.40m SSL
LVE2 | 00 Ground floor | 0.40 m | CC= 2.90m FCL | X=12.18 | CC= 0.40m FFB | CC= 0.40m SSL | NN=0.20 m | Dra.no: 1 | 00.20 | Storey: 2 | Y=22.34 | Top= 2.90m FCL | NNUK=0.20 m | Edge= 0.40m SSL
LVE2 | 00 Ground floor | 0.30 m | CC= 3.00m FCL | X=11.87 | CC= 0.30m FFB | CC= 0.30m SSL | NN=0.10 m | Dra.no: 1 | 00.20 | Storey: 2 | Y=17.13 | Top= 3.00m FCL | NNUK=0.10 m | Edge= 0.30m SSL
LVE2 | 00 Ground floor | 0.30 m | CC= 3.00m FCL | X=9.99 | CC= 0.30m FFB | CC= 0.30m SSL | NN=0.10 m | Dra.no: 1 | 00.20 | Storey: 2 | Y=17.13 | Top= 3.00m FCL | NNUK=0.10 m | Edge= 0.30m SSL
LVE2 | 01 First floor | 0.40 m | CC= 2.78m FCL | X=17.17 | CC= 0.52m FFB | CC= 0.52m SSL | NN=3.70 m | Dra.no: 2 | 01.19 | Storey: 3 | Y=22.34 | Top= 2.78m FCL | NNUK=3.70 m | Edge= 0.52m SSL
LVE2 | 01 First floor | 0.40 m | CC= 2.78m FCL | X=21.16 | CC= 0.52m FFB | CC= 0.52m SSL | NN=3.70 m | Dra.no: 2 | 01.19 | Storey: 3 | Y=22.34 | Top= 2.78m FCL | NNUK=3.70 m | Edge= 0.52m SSL
LVE2 | 01 First floor | 0.30 m | CC= 2.88m FCL | X=20.85 | CC= 0.42m FFB | CC= 0.42m SSL | NN=3.60 m | Dra.no: 2 | 01.19 | Storey: 3 | Y=17.13 | Top= 2.88m FCL | NNUK=3.60 m | Edge= 0.42m SSL
LVE2 | 01 First floor | 0.30 m | CC= 2.88m FCL | X=18.97 | CC= 0.42m FFB | CC= 0.42m SSL | NN=3.60 m | Dra.no: 2 | 01.19 | Storey: 3 | Y=17.13 | Top= 2.88m FCL | NNUK=3.60 m | Edge= 0.42m SSL
LVE2 | 01 First floor | 0.40 m | CC= 2.78m FCL | X=12.67 | CC= 0.52m FFB | CC= 0.52m SSL | NN=3.70 m | Dra.no: 2 | 01.20 | Storey: 3 | Y=22.34 | Top= 2.78m FCL | NNUK=3.70 m | Edge= 0.52m SSL
LVE2 | 01 First floor | 0.40 m | CC= 2.78m FCL | X=16.66 | CC= 0.52m FFB | CC= 0.52m SSL | NN=3.70 m | Dra.no: 2 | 01.20 | Storey: 3 | Y=22.34 | Top= 2.78m FCL | NNUK=3.70 m | Edge= 0.52m SSL
LVE2 | 01 First floor | 0.30 m | CC= 2.88m FCL | X=16.35 | CC= 0.42m FFB | CC= 0.42m SSL | NN=3.60 m | Dra.no: 2 | 01.20 | Storey: 3 | Y=17.13 | Top= 2.88m FCL | NNUK=3.60 m | Edge= 0.42m SSL
LVE2 | 01 First floor | 0.30 m | CC= 2.88m FCL | X=14.47 | CC= 0.42m FFB | CC= 0.42m SSL | NN=3.60 m | Dra.no: 2 | 01.20 | Storey: 3 | Y=17.13 | Top= 2.88m FCL | NNUK=3.60 m | Edge= 0.42m SSL
LVE2 | 01 First floor | 0.40 m | CC= 2.78m FCL | X=8.18 | CC= 0.52m FFB | CC= 0.52m SSL | NN=3.70 m | Dra.no: 2 | 01.18 | Storey: 3 | Y=22.34 | Top= 2.78m FCL | NNUK=3.70 m | Edge= 0.52m SSL
LVE2 | 01 First floor | 0.40 m | CC= 2.78m FCL | X=12.18 | CC= 0.52m FFB | CC= 0.52m SSL | NN=3.70 m | Dra.no: 2 | 01.18 | Storey: 3 | Y=22.34 | Top= 2.78m FCL | NNUK=3.70 m | Edge= 0.52m SSL
LVE2 | 01 First floor | 0.30 m | CC= 2.88m FCL | X=11.87 | CC= 0.42m FFB | CC= 0.42m SSL | NN=3.60 m | Dra.no: 2 | 01.18 | Storey: 3 | Y=17.13 | Top= 2.88m FCL | NNUK=3.60 m | Edge= 0.42m SSL
LVE2 | 01 First floor | 0.30 m | CC= 2.88m FCL | X=9.99 | CC= 0.42m FFB | CC= 0.42m SSL | NN=3.60 m | Dra.no: 2 | 01.18 | Storey: 3 | Y=17.13 | Top= 2.88m FCL | NNUK=3.60 m | Edge= 0.42m SSL

# IfcFlowTerminal: BAN11/60 (6)
Type - Description: Wash basin 600x480 mm; ApplicableOccurrence: Generic; PredefinedType: SINK
Type - Pset_ManufacturerTypeInformation - ArticleNumber: BAN11/60; ModelReference: Wash basin 600x480 mm; ModelLabel: SI; Manufacturer: DDS
Type - Pset_SanitaryTerminalTypeSink - NominalLength: 600 mm; NominalWidth: 480 mm; NominalDepth: 210 mm; DrainSize: 40 mm
Material: IFC Building Material
Pset_DDS - Mounting Height: 0.00 m; Product: Wash basin 600x480 mm; Dimension DN: 480 mm; Manufacturer: DDS; X: X=22.12; Width: 480; Layer number: 20; Length: 600; Project name: OpenBIM; Room tekst: corridor; Product Number: BAN11/60; Building Part: Building: 0
Pset_DistributionFlowElementCommon - Reference: BAN11/60
AC_Pset_RenovationAndPhasing - Renovation Status: Existing
Name | In | Y | Mtg. above Finished Floor ref Center | Above Sea Level ref. Bottom | Model Number | Mtg. Above Slab ref Center | Floor number | Mtg. Below Ceiling ref Center | Mtg. Below Ceiling ref Top | Room number | Mtg. Above Slab ref Bottom | Above Sea Level ref. Center
Basin/Sink/Bidet | 00 Ground floor | Y=13.60 | CC= 0.11m FFB | NNUK=-0.20 m | Dra.no: 1 | CC= 0.11m SSL | Storey: 2 | CC= 3.19m FCL | Top= 3.09m FCL | 00.04 | Edge= 0.00m SSL | NN=-0.09 m
Basin/Sink/Bidet | 00 Ground floor | Y=12.56 | CC= 0.11m FFB | NNUK=-0.20 m | Dra.no: 1 | CC= 0.11m SSL | Storey: 2 | CC= 3.19m FCL | Top= 3.09m FCL | 00.04 | Edge= 0.00m SSL | NN=-0.09 m
Basin/Sink/Bidet | 00 Ground floor | Y=14.64 | CC= 0.11m FFB | NNUK=-0.20 m | Dra.no: 1 | CC= 0.11m SSL | Storey: 2 | CC= 3.19m FCL | Top= 3.09m FCL | 00.04 | Edge= 0.00m SSL | NN=-0.09 m
Basin/Sink/Bidet | 01 First floor | Y=12.56 | CC= -0.03m FFB | NNUK=3.30 m | Dra.no: 2 | CC= -0.03m SSL | Storey: 3 | CC= 3.33m FCL | Top= 3.22m FCL | 01.04 | Edge= -0.13m SSL | NN=3.41 m
Basin/Sink/Bidet | 01 First floor | Y=13.60 | CC= -0.03m FFB | NNUK=3.30 m | Dra.no: 2 | CC= -0.03m SSL | Storey: 3 | CC= 3.33m FCL | Top= 3.22m FCL | 01.04 | Edge= -0.13m SSL | NN=3.41 m
Basin/Sink/Bidet | 01 First floor | Y=14.64 | CC= -0.03m FFB | NNUK=3.30 m | Dra.no: 2 | CC= -0.03m SSL | Storey: 3 | CC= 3.33m FCL | Top= 3.22m FCL | 01.04 | Edge= -0.13m SSL | NN=3.41 m

# IfcFlowTerminal: BK-05062012-007 (10)
Type - Description: Pre wall installed WC service up in front; ApplicableOccurrence: Basic; ElementType: BK_BK-05062012-007_1052_129_0_0_0F_Z0; PredefinedType: USERDEFINED
Type - Pset_ManufacturerTypeInformation - ArticleNumber: BK-05062012-007; ModelReference: Pre wall installed WC service up in front; Manufacturer: DDS
Type - Pset_SanitaryTerminalTypeSink - NominalLength: 0.1 mm; NominalWidth: 0.1 mm; NominalDepth: 0.1 mm; DrainSize: 40 mm
Material: IFC Building Material
Pset_DDS - Mounting Height: 0.00 m; Manufacturer: DDS; Product Number: BK-05062012-007; Dimension DN: 0 mm; Layer number: 20; Product: Pre wall installed WC service up in front; Project name: OpenBIM; Width: 0; Length: 0; Building Part: Building: 0
Pset_DistributionFlowElementCommon - Reference: BK-05062012-007
AC_Pset_RenovationAndPhasing - Renovation Status: Existing
Name | In | Mtg. Below Ceiling ref Center | Mtg. above Finished Floor ref Center | Mtg. Above Slab ref Center | X | Y | Mtg. Below Ceiling ref Top | Above Sea Level ref. Bottom | System Name | Above Sea Level ref. Center | Model Number | Floor number | Room tekst | Room number | Mtg. Above Slab ref Bottom | Group
Copper pipes length 5 m 35x1,5 mm | 00 Ground floor | CC= 3.30m FCL | CC= 0.00m FFB | CC= 0.00m SSL | X=22.17 | Y=13.04 | Top= 3.30m FCL | NNUK=-0.20 m | PW | NN=-0.20 m | Dra.no: 1 | Storey: 2 | corridor | 00.04 | Edge= 0.00m SSL | Coldwater
Copper pipes length 5 m 35x1,5 mm | 00 Ground floor | CC= 3.30m FCL | CC= 0.00m FFB | CC= 0.00m SSL | X=22.16 | Y=14.16 | Top= 3.30m FCL | NNUK=-0.20 m | PW | NN=-0.20 m | Dra.no: 1 | Storey: 2 | corridor | 00.04 | Edge= 0.00m SSL | Coldwater
Copper pipes length 5 m 35x1,5 mm | 00 Ground floor | CC= 3.30m FCL | CC= 0.00m FFB | CC= 0.00m SSL | X=18.62 | Y=14.66 | Top= 3.30m FCL | NNUK=-0.20 m | PW | NN=-0.20 m | Dra.no: 1 | Storey: 2 | Office | 00.18 | Edge= 0.00m SSL | Coldwater
Copper pipes length 5 m 35x1,5 mm | 00 Ground floor | CC= 3.30m FCL | CC= 0.00m FFB | CC= 0.00m SSL | X=18.62 | Y=12.52 | Top= 3.30m FCL | NNUK=-0.20 m | PW | NN=-0.20 m | Dra.no: 1 | Storey: 2 | Office | 00.18 | Edge= 0.00m SSL | Coldwater
Copper pipes length 5 m 35x1,5 mm | 00 Ground floor | CC= 3.30m FCL | CC= 0.00m FFB | CC= 0.00m SSL | X=18.62 | Y=13.60 | Top= 3.30m FCL | NNUK=-0.20 m | PW | NN=-0.20 m | Dra.no: 1 | Storey: 2 | Office | 00.18 | Edge= 0.00m SSL | Coldwater
Copper pipes length 5 m 35x1,5 mm | 01 First floor | CC= 3.43m FCL | CC= -0.13m FFB | CC= -0.13m SSL | X=18.62 | Y=14.66 | Top= 3.43m FCL | NNUK=3.30 m | PW | NN=3.30 m | Dra.no: 2 | Storey: 3 | Kitchen | 01.16 | Edge= -0.13m SSL | Coldwater
Copper pipes length 5 m 35x1,5 mm | 01 First floor | CC= 3.43m FCL | CC= -0.13m FFB | CC= -0.13m SSL | X=18.62 | Y=13.60 | Top= 3.43m FCL | NNUK=3.30 m | PW | NN=3.30 m | Dra.no: 2 | Storey: 3 | Kitchen | 01.16 | Edge= -0.13m SSL | Coldwater
Copper pipes length 5 m 35x1,5 mm | 01 First floor | CC= 3.43m FCL | CC= -0.13m FFB | CC= -0.13m SSL | X=22.17 | Y=14.16 | Top= 3.43m FCL | NNUK=3.30 m | PW | NN=3.30 m | Dra.no: 2 | Storey: 3 | corridor | 01.04 | Edge= -0.13m SSL | Coldwater
Copper pipes length 5 m 35x1,5 mm | 01 First floor | CC= 3.30m FCL | CC= 0.00m FFB | CC= 0.00m SSL | X=22.18 | Y=13.04 | Top= 0.00m FCL | NNUK=3.30 m | PW | NN=3.30 m | Dra.no: 2 | Storey: 3 |  |  | Edge= 0.00m SSL | Coldwater
Copper pipes length 5 m 35x1,5 mm | 01 First floor | CC= 3.43m FCL | CC= -0.13m FFB | CC= -0.13m SSL | X=18.62 | Y=12.52 | Top= 3.43m FCL | NNUK=3.30 m |  | NN=3.30 m | Dra.no: 2 | Storey: 3 | Kitchen | 01.16 | Edge= -0.13m SSL

# IfcFlowTerminal: BSN40/45 (4)
Type - Description: Hand basin 450x355 mm; ApplicableOccurrence: Generic; PredefinedType: SINK
Type - Pset_ManufacturerTypeInformation - ArticleNumber: BSN40/45; ModelReference: Hand basin 450x355 mm; ModelLabel: SI; Manufacturer: DDS
Type - Pset_SanitaryTerminalTypeSink - NominalLength: 450 mm; NominalWidth: 355 mm; NominalDepth: 210 mm; DrainSize: 40 mm
Material: IFC Building Material
Pset_DDS - Mounting Height: 0.00 m; Product Number: BSN40/45; Manufacturer: DDS; Room tekst: wc; Layer number: 20; Project name: OpenBIM; Dimension DN: 355 mm; Product: Hand basin 450x355 mm; X: X=23.21; Width: 355; Length: 450; Building Part: Building: 0
Pset_DistributionFlowElementCommon - Reference: BSN40/45
AC_Pset_RenovationAndPhasing - Renovation Status: Existing
Name | In | Y | Mtg. above Finished Floor ref Center | Above Sea Level ref. Bottom | Model Number | Mtg. Above Slab ref Center | Floor number | Mtg. Below Ceiling ref Center | Mtg. Below Ceiling ref Top | Room number | Mtg. Above Slab ref Bottom | Above Sea Level ref. Center
Basin/Sink/Bidet | 00 Ground floor | Y=15.16 | CC= 0.11m FFB | NNUK=-0.20 m | Dra.no: 1 | CC= 0.11m SSL | Storey: 2 | CC= 3.19m FCL | Top= 3.09m FCL | 00.09 | Edge= 0.00m SSL | NN=-0.09 m
Basin/Sink/Bidet | 00 Ground floor | Y=12.03 | CC= 0.11m FFB | NNUK=-0.20 m | Dra.no: 1 | CC= 0.11m SSL | Storey: 2 | CC= 3.19m FCL | Top= 3.09m FCL | 00.10 | Edge= 0.00m SSL | NN=-0.09 m
Basin/Sink/Bidet | 01 First floor | Y=12.04 | CC= -0.03m FFB | NNUK=3.30 m | Dra.no: 2 | CC= -0.03m SSL | Storey: 3 | CC= 3.33m FCL | Top= 3.22m FCL | 01.10 | Edge= -0.13m SSL | NN=3.41 m
Basin/Sink/Bidet | 01 First floor | Y=15.16 | CC= -0.03m FFB | NNUK=3.30 m | Dra.no: 2 | CC= -0.03m SSL | Storey: 3 | CC= 3.33m FCL | Top= 3.22m FCL | 01.11 | Edge= -0.13m SSL | NN=3.41 m

# IfcFlowTerminal: GV00655 (5)
In: 00 Ground floor
Type - Description: Wall Grille with Plenum before, DN 160; ApplicableOccurrence: Supply; PredefinedType: DIFFUSER
Type - Pset_ManufacturerTypeInformation - ArticleNumber: GV00655; ModelReference: Wall Grille with Plenum before, DN 160; ModelLabel: GV; Manufacturer: DDS
Type - Pset_AirTerminalTypeCommon - NeckArea: 0.0201062 m2
Material: IFC Building Material; Group: Supply air
Pset_DDS - Dimension DN: 160 mm; Cu fitting bend 90\X\B0 35x1,5 mm: 160 mm; Mounting Height: 3.20 m; Product Number: GV00655; Mtg. Below Ceiling ref Center: CC= 0.30m FCL; Above Sea Level ref. Center: NN=3.00 m; Mtg. Above Slab ref Bottom: Edge= 3.12m SSL; Main string number: 01; Above Sea Level ref. Bottom: NNUK=2.84 m; Mtg. above Finished Floor ref Center: CC= 3.20m FFB; Manufacturer: DDS; Mtg. Above Slab ref Center: CC= 3.20m SSL; Ins thickness: ins= 0.000000 mm; Mtg. Below Ceiling ref Top: Top= 0.22m FCL; Air supply: 110.0 m\X\B3/h; Flow (m\X\B3/h): 110.0 m\X\B3/h; System Name: Supply Air; Medium: Supply Air; Flow (l/s): 30.56 l/s; Length: 400.0 m; Model Number: Dra.no: 1; Part number: .002; Layer number: 10; Project name: OpenBIM; Height: 0; Insulation k-value: 0; Air terminal position: 1; Insulation WSVO: 0; Pressure drop: 0; Floor number: Storey: 2; Flow (l/h): 110000.000000 l/h; Room tekst: Entrance; Pipe thickness:: x0.0; Width: 160; Room number: 00.01; Rotation: 0.000000; Outside dimension: 0.000000; Velocity: 5470.95 m/s; Product: Wall Grille with Plenum before, DN 160; Building Part: Building: 0; Y: Y=6.83; Abs. pressure: 0.0 Pa
Pset_DistributionFlowElementCommon - Reference: GV00655
AC_Pset_RenovationAndPhasing - Renovation Status: Existing
Name | Sound | Sub string number | X
1.24.2 | 8.2 dB(A) | .0024 | X=15.63
1.25.2 | 8.4 dB(A) | .0025 | X=19.19
1.26.2 | 8.6 dB(A) | .0026 | X=22.75
1.27.2 | 8.8 dB(A) | .0027 | X=26.31
1.28.2 | 9.6 dB(A) | .0028 | X=29.87

# IfcFlowTerminal: GV011200x200 (13)
Type - Description: Rect. Ceiling Diffuser 200x200 200 m\X\B3/h (0.056 m3/s); ApplicableOccurrence: Supply; PredefinedType: DIFFUSER
Type - Pset_ManufacturerTypeInformation - ArticleNumber: GV011200x200; ModelReference: Rect. Ceiling Diffuser 200x200 200 m\X\B3/h (0.056 m3/s); ModelLabel: GV; Manufacturer: DDS
Type - Pset_AirTerminalTypeCommon - NeckArea: 0.0201062 m2
Material: IFC Building Material; Group: Supply air
Pset_DDS - Dimension DN: 160 mm; Cu fitting bend 90\X\B0 35x1,5 mm: 160 mm; Part number: .006; Mounting Height: 2.70 m; Main string number: 01; Manufacturer: DDS; Ins thickness: ins= 0.000000 mm; Air supply: 200.0 m\X\B3/h; Flow (m\X\B3/h): 200.0 m\X\B3/h; System Name: Supply Air; Medium: Supply Air; Length: 160.0 m; Flow (l/s): 55.56 l/s; Product: Rect. Ceiling Diffuser 200x200 200 m\X\B3/h (0.056 m3/s); Project name: OpenBIM; Flow (l/h): 200000.000000 l/h; Height: 0; Insulation k-value: 0; Air terminal position: 1; Insulation WSVO: 0; Pipe thickness:: x0.0; Pressure drop: 46; Width: 160; Rotation: 0.000000; Outside dimension: 0.000000; Y: Y=19.73; Product Number: GV011200x200; Building Part: Building: 0; Velocity: 9947.18 m/s; Abs. pressure: 0.0 Pa
Pset_DistributionFlowElementCommon - Reference: GV011200x200
AC_Pset_RenovationAndPhasing - Renovation Status: Existing
Name | In | Mtg. Below Ceiling ref Top | X | Above Sea Level ref. Center | Mtg. Below Ceiling ref Center | Mtg. Above Slab ref Bottom | Mtg. above Finished Floor ref Center | Mtg. Above Slab ref Center | Sound | Sub string number | Room tekst | Model Number | Layer number | Room number | Above Sea Level ref. Bottom | Floor number
1.10.6 | 00 Ground floor | Top= 0.52m FCL | X=18.19 | NN=2.50 m | CC= 0.60m FCL | Edge= 2.62m SSL | CC= 2.70m FFB | CC= 2.70m SSL | 27.9 dB(A) | .0010 | Office | Dra.no: 1 | 25 | 001 | NNUK=2.34 m | Storey: 2
1.17.6 | 00 Ground floor | Top= 0.52m FCL | X=20.06 | NN=2.50 m | CC= 0.60m FCL | Edge= 2.62m SSL | CC= 2.70m FFB | CC= 2.70m SSL | 28.2 dB(A) | .0017 | Office | Dra.no: 1 | 25 | 001 | NNUK=2.34 m | Storey: 2
1.6.6 | 00 Ground floor | Top= 0.52m FCL | X=9.53 | NN=2.50 m | CC= 0.60m FCL | Edge= 2.62m SSL | CC= 2.70m FFB | CC= 2.70m SSL | 26.2 dB(A) | .0006 | Office | Dra.no: 1 | 25 | 00.20 | NNUK=2.34 m | Storey: 2
1.7.6 | 00 Ground floor | Top= 0.52m FCL | X=10.78 | NN=2.50 m | CC= 0.60m FCL | Edge= 2.62m SSL | CC= 2.70m FFB | CC= 2.70m SSL | 26.4 dB(A) | .0007 | Office | Dra.no: 1 | 25 | 00.20 | NNUK=2.34 m | Storey: 2
1.8.6 | 00 Ground floor | Top= 0.52m FCL | X=13.69 | NN=2.50 m | CC= 0.60m FCL | Edge= 2.62m SSL | CC= 2.70m FFB | CC= 2.70m SSL | 27.0 dB(A) | .0008 | Office | Dra.no: 1 | 25 | 00.21 | NNUK=2.34 m | Storey: 2
1.9.6 | 00 Ground floor | Top= 0.52m FCL | X=15.56 | NN=2.50 m | CC= 0.60m FCL | Edge= 2.62m SSL | CC= 2.70m FFB | CC= 2.70m SSL | 27.4 dB(A) | .0009 | Office | Dra.no: 1 | 25 | 00.21 | NNUK=2.34 m | Storey: 2
1.35.6 | 01 First floor | Top= 0.40m FCL | X=8.91 | NN=6.00 m | CC= 0.48m FCL | Edge= 2.74m SSL | CC= 2.82m FFB | CC= 2.82m SSL | 8.4 dB(A) | .0035 | Office | Dra.no: 2 | 10 | 01.18 | NNUK=5.84 m | Storey: 3
1.36.6 | 01 First floor | Top= 0.40m FCL | X=11.41 | NN=6.00 m | CC= 0.48m FCL | Edge= 2.74m SSL | CC= 2.82m FFB | CC= 2.82m SSL | 8.6 dB(A) | .0036 | Office | Dra.no: 2 | 10 | 01.18 | NNUK=5.84 m | Storey: 3
1.37.6 | 01 First floor | Top= 0.40m FCL | X=13.69 | NN=6.00 m | CC= 0.48m FCL | Edge= 2.74m SSL | CC= 2.82m FFB | CC= 2.82m SSL | 8.7 dB(A) | .0037 | Office | Dra.no: 2 | 10 | 01.20 | NNUK=5.84 m | Storey: 3
1.38.6 | 01 First floor | Top= 0.40m FCL | X=15.56 | NN=6.00 m | CC= 0.48m FCL | Edge= 2.74m SSL | CC= 2.82m FFB | CC= 2.82m SSL | 8.8 dB(A) | .0038 | Office | Dra.no: 2 | 10 | 01.20 | NNUK=5.84 m | Storey: 3
1.39.6 | 01 First floor | Top= 0.40m FCL | X=18.19 | NN=6.00 m | CC= 0.48m FCL | Edge= 2.74m SSL | CC= 2.82m FFB | CC= 2.82m SSL | 8.9 dB(A) | .0039 | Office | Dra.no: 2 | 10 | 01.19 | NNUK=5.84 m | Storey: 3
1.40.6 | 01 First floor | Top= 0.40m FCL | X=20.06 | NN=6.00 m | CC= 0.48m FCL | Edge= 2.74m SSL | CC= 2.82m FFB | CC= 2.82m SSL | 9.1 dB(A) | .0040 | Office | Dra.no: 2 | 10 | 01.19 | NNUK=5.84 m | Storey: 3
1.41.6 | 01 First floor | Top= 0.40m FCL | X=22.19 | NN=6.00 m | CC= 0.48m FCL | Edge= 2.74m SSL | CC= 2.82m FFB | CC= 2.82m SSL | 9.2 dB(A) | .0041 | Storage | Dra.no: 2 | 10 | 01.13 | NNUK=5.84 m | Storey: 3

# IfcFlowTerminal: GV017200x200 (5)
In: 00 Ground floor
Type - Description: Rect. Ceiling Diffuser 200 200 m\X\B3/h (0.056 m3/s); ApplicableOccurrence: Supply; PredefinedType: DIFFUSER
Type - Pset_ManufacturerTypeInformation - ArticleNumber: GV017200x200; ModelReference: Rect. Ceiling Diffuser 200 200 m\X\B3/h (0.056 m3/s); ModelLabel: GV; Manufacturer: DDS
Type - Pset_AirTerminalTypeCommon - NeckArea: 0.0201062 m2
Material: IFC Fill; Group: Supply air
Pset_DDS - Dimension DN: 160 mm; Cu fitting bend 90\X\B0 35x1,5 mm: 160 mm; Mtg. Below Ceiling ref Top: Top= 0.52m FCL; Part number: .006; Mounting Height: 2.70 m; Above Sea Level ref. Center: NN=2.50 m; Mtg. Below Ceiling ref Center: CC= 0.60m FCL; Mtg. Above Slab ref Bottom: Edge= 2.62m SSL; Main string number: 01; Mtg. above Finished Floor ref Center: CC= 2.70m FFB; Manufacturer: DDS; Mtg. Above Slab ref Center: CC= 2.70m SSL; Ins thickness: ins= 0.000000 mm; Air supply: 200.0 m\X\B3/h; Flow (m\X\B3/h): 200.0 m\X\B3/h; System Name: Supply Air; Medium: Supply Air; Length: 150.0 m; Flow (l/s): 55.56 l/s; Room tekst: Office; Model Number: Dra.no: 1; Project name: OpenBIM; Flow (l/h): 200000.000000 l/h; Height: 0; Insulation k-value: 0; Air terminal position: 1; Insulation WSVO: 0; Above Sea Level ref. Bottom: NNUK=2.34 m; Floor number: Storey: 2; Pipe thickness:: x0.0; Pressure drop: 46; Width: 160; Product: Rect. Ceiling Diffuser 200 200 m\X\B3/h (0.056 m3/s); Rotation: 0.000000; Outside dimension: 0.000000; Product Number: GV017200x200; Building Part: Building: 0; Velocity: 9947.18 m/s; Abs. pressure: 0.0 Pa
Pset_DistributionFlowElementCommon - Reference: GV017200x200
AC_Pset_RenovationAndPhasing - Renovation Status: Existing
Name | X | Sub string number | Room number | Layer number | Sound | Y
1.12.6 | X=6.75 | .0012 | 00.19 | 10 | 23.6 dB(A) | Y=12.57
1.13.6 | X=8.63 | .0013 | 00.19 | 10 | 24.0 dB(A) | Y=12.57
1.14.6 | X=13.75 | .0014 | 00.17 | 25 | 25.4 dB(A) | Y=13.29
1.15.6 | X=15.94 | .0015 | 00.18 | 25 | 25.8 dB(A) | Y=13.29
1.16.6 | X=17.81 | .0016 | 00.18 | 25 | 26.1 dB(A) | Y=13.29

# IfcFlowTerminal: GV121000x30 (3)
In: 00 Ground floor
Type - Description: Slot Diffuser 30 mm 1,0 m 100 m\X\B3/h (0.028 m3/s); ApplicableOccurrence: Supply; PredefinedType: DIFFUSER
Type - Pset_ManufacturerTypeInformation - ArticleNumber: GV121000x30; ModelReference: Slot Diffuser 30 mm 1,0 m 100 m\X\B3/h (0.028 m3/s); ModelLabel: GV; Manufacturer: DDS
Type - Pset_AirTerminalTypeCommon - NeckArea: 0.0122718 m2
Material: IFC Building Material; Group: Supply air
Pset_DDS - Mounting Height: 2.70 m; Above Sea Level ref. Center: NN=2.50 m; Main string number: 01; Y: Y=8.55; Manufacturer: DDS; Width: 125; Ins thickness: ins= 0.000000 mm; Air supply: 100.0 m\X\B3/h; Flow (m\X\B3/h): 100.0 m\X\B3/h; System Name: Supply Air; Medium: Supply Air; Cu fitting bend 90\X\B0 35x1,5 mm: 125 mm; Dimension DN: 125 mm; Velocity: 8148.73 m/s; Model Number: Dra.no: 1; Layer number: 10; Product: Slot Diffuser 30 mm 1,0 m 100 m\X\B3/h (0.028 m3/s); Project name: OpenBIM; Height: 0; Insulation k-value: 0; Air terminal position: 1; Insulation WSVO: 0; Above Sea Level ref. Bottom: NNUK=2.38 m; Floor number: Storey: 2; Product Number: GV121000x30; Pressure drop: 25; Length: 1000.0 m; Pipe thickness:: x0.0; Room tekst: Director office; Rotation: 0.000000; Outside dimension: 0.000000; Flow (l/s): 27.78 l/s; Flow (l/h): 100000.000000 l/h; Building Part: Building: 0; Abs. pressure: 0.0 Pa
Pset_DistributionFlowElementCommon - Reference: GV121000x30
AC_Pset_RenovationAndPhasing - Renovation Status: Existing
Name | Mtg. Above Slab ref Center | Mtg. Below Ceiling ref Top | Sub string number | X | Part number | Mtg. Below Ceiling ref Center | Sound | Mtg. Above Slab ref Bottom | Room number | Mtg. above Finished Floor ref Center
1.31.11 | CC= 2.82m SSL | Top= 0.42m FCL | .0031 | X=38.75 | .011 | CC= 0.48m FCL | 6.5 dB(A) | Edge= 2.76m SSL | 00.24 | CC= 2.82m FFB
1.32.6 | CC= 2.57m SSL | Top= 0.67m FCL | .0032 | X=35.00 | .006 | CC= 0.73m FCL | 6.3 dB(A) | Edge= 2.51m SSL | 00.25 | CC= 2.57m FFB
1.33.6 | CC= 2.57m SSL | Top= 0.67m FCL | .0033 | X=33.12 | .006 | CC= 0.73m FCL | 6.0 dB(A) | Edge= 2.51m SSL | 00.25 | CC= 2.57m FFB

# IfcFlowTerminal: GV21_125#002 (11)
In: 00 Ground floor
Type - Description: Air Valve 125 \X\D8155; ApplicableOccurrence: Extract; PredefinedType: REGISTER
Type - Pset_ManufacturerTypeInformation - ArticleNumber: GV21_125#002; ModelReference: Air Valve 125 \X\D8155; ModelLabel: GV; Manufacturer: DDS
Type - Pset_AirTerminalTypeCommon - NeckArea: 0.0122718 m2
Material: IFC Building Material
Pset_DDS - Mounting Height: 2.70 m; Product Number: GV21_125#002; Above Sea Level ref. Center: NN=2.50 m; Product: Air Valve 125 \X\D8155; Manufacturer: DDS; Width: 125; Ins thickness: ins= 0.000000 mm; Air supply: 100.0 m\X\B3/h; Flow (m\X\B3/h): 100.0 m\X\B3/h; Cu fitting bend 90\X\B0 35x1,5 mm: 125 mm; Dimension DN: 125 mm; Velocity: 8148.73 m/s; Model Number: Dra.no: 1; Length: 125.0 m; Main string number: 00; Project name: OpenBIM; Height: 0; Insulation k-value: 0; Air terminal position: 1; Insulation WSVO: 0; Pressure drop: 0; Above Sea Level ref. Bottom: NNUK=2.38 m; Floor number: Storey: 2; Pipe thickness:: x0.0; Part number: .000; Rotation: 0.000000; Outside dimension: 0.000000; Flow (l/s): 27.78 l/s; Flow (l/h): 100000.000000 l/h; Building Part: Building: 0; Medium: Extract Air; Abs. pressure: 0.0 Pa
Pset_DistributionFlowElementCommon - Reference: GV21_125#002
AC_Pset_RenovationAndPhasing - Renovation Status: Existing
Name | Mtg. Below Ceiling ref Top | Y | Mtg. Below Ceiling ref Center | Mtg. Above Slab ref Bottom | Mtg. above Finished Floor ref Center | X | Mtg. Above Slab ref Center | Room tekst | Sound | Layer number | Sub string number | Room number
AirTerminal | Top= 0.54m FCL | Y=13.91 | CC= 0.60m FCL | Edge= 2.64m SSL | CC= 2.70m FFB | X=23.31 | CC= 2.70m SSL | wc | 4.0 dB(A) | 25 | .0000 | 00.09
AirTerminal | Top= 0.54m FCL | Y=12.66 | CC= 0.60m FCL | Edge= 2.64m SSL | CC= 2.70m FFB | X=19.56 | CC= 2.70m SSL | wc | 9.2 dB(A) | 11 | .0000 | 00.06
AirTerminal | Top= 0.54m FCL | Y=13.85 | CC= 0.60m FCL | Edge= 2.64m SSL | CC= 2.70m FFB | X=19.56 | CC= 2.70m SSL | wc | 4.0 dB(A) | 11 | .0000 | 00.08
AirTerminal | Top= 0.54m FCL | Y=14.54 | CC= 0.60m FCL | Edge= 2.64m SSL | CC= 2.70m FFB | X=19.56 | CC= 2.70m SSL | wc | 4.0 dB(A) | 11 | .0000 | 00.07
AirTerminal | Top= 0.54m FCL | Y=12.66 | CC= 0.60m FCL | Edge= 2.64m SSL | CC= 2.70m FFB | X=23.31 | CC= 2.70m SSL | wc | 4.0 dB(A) | 25 | .0000 | 00.10
AirTerminal | Top= 0.54m FCL | Y=13.32 | CC= 0.60m FCL | Edge= 2.64m SSL | CC= 2.70m FFB | X=21.44 | CC= 2.70m SSL | corridor | 4.0 dB(A) | 25 | .0000 | 00.04
AirTerminal | Top= 0.67m FCL | Y=9.74 | CC= 0.73m FCL | Edge= 2.51m SSL | CC= 2.57m FFB | X=30.20 | CC= 2.57m SSL | FB | 4.0 dB(A) | 25 | .0019 | 00.15
AirTerminal | Top= 0.42m FCL | Y=11.22 | CC= 0.48m FCL | Edge= 2.76m SSL | CC= 2.82m FFB | X=39.91 | CC= 2.82m SSL | Storage | 4.0 dB(A) | 25 | .0019 | 00.11
AirTerminal | Top= 0.42m FCL | Y=13.16 | CC= 0.48m FCL | Edge= 2.76m SSL | CC= 2.82m FFB | X=39.87 | CC= 2.82m SSL | Storage | 4.0 dB(A) | 25 | .0019 | 00.12
AirTerminal | Top= 0.54m FCL | Y=13.19 | CC= 0.60m FCL | Edge= 2.64m SSL | CC= 2.70m FFB | X=10.94 | CC= 2.70m SSL | Storage | 4.0 dB(A) | 25 | .0019 | 00.13
AirTerminal | Top= 0.54m FCL | Y=17.56 | CC= 0.60m FCL | Edge= 2.64m SSL | CC= 2.70m FFB | X=22.58 | CC= 2.70m SSL | Storage | 4.0 dB(A) | 25 | .0019 | 00.22

# IfcFlowTerminal: HLH0900 (4)
In: 00 Ground floor
Type - Description: Induction Diffuser Ceiling H-LH 1500 x 593 mm; ApplicableOccurrence: Supply; PredefinedType: DIFFUSER
Type - Pset_ManufacturerTypeInformation - ArticleNumber: HLH0900; ModelReference: Induction Diffuser Ceiling H-LH 1500 x 593 mm; ModelLabel: GV; Manufacturer: DDS
Type - Pset_AirTerminalTypeCommon - NeckArea: 0.0122718 m2
Material: IFC Building Material
Pset_DDS - Mtg. Above Slab ref Center: CC= 2.82m SSL; Mounting Height: 2.70 m; Above Sea Level ref. Center: NN=2.50 m; Mtg. Below Ceiling ref Top: Top= 0.42m FCL; Flow (l/h): 108000.000000 l/h; Flow (l/s): 30.00 l/s; Manufacturer: DDS; Width: 125; Ins thickness: ins= 0.000000 mm; Air supply: 108.0 m\X\B3/h; Flow (m\X\B3/h): 108.0 m\X\B3/h; Sub string number: .0010; Cu fitting bend 90\X\B0 35x1,5 mm: 125 mm; Dimension DN: 125 mm; Mtg. Below Ceiling ref Center: CC= 0.48m FCL; Room tekst: Office; Model Number: Dra.no: 1; Mtg. Above Slab ref Bottom: Edge= 2.76m SSL; Layer number: 25; Product Number: HLH0900; Room number: 00.23; Project name: OpenBIM; Height: 0; Insulation k-value: 0; Air terminal position: 1; Insulation WSVO: 0; Pressure drop: 0; Above Sea Level ref. Bottom: NNUK=2.38 m; Product: Induction Diffuser Ceiling H-LH 1500 x 593 mm; Velocity: 8800.63 m/s; Floor number: Storey: 2; Length: 380.0 m; Part number: .008; Pipe thickness:: x0.0; Rotation: 0.000000; Outside dimension: 0.000000; Building Part: Building: 0; Mtg. above Finished Floor ref Center: CC= 2.82m FFB; Abs. pressure: 0.0 Pa
Pset_DistributionFlowElementCommon - Reference: HLH0900
AC_Pset_RenovationAndPhasing - Renovation Status: Existing
Name | Sound | Main string number | X | Medium | Y | Group
1.10.8 | 19.9 dB(A) | 01 | X=38.75 | Supply Air | Y=19.80 | Supply air | Pset_DDS - System Name: Supply Air
1.10.8 | 19.8 dB(A) | 01 | X=38.75 | Supply Air | Y=16.05 | Supply air | Pset_DDS - System Name: Supply Air
2.10.8 | 17.9 dB(A) | 02 | X=35.62 | Extract Air | Y=19.80 | Cooling flow
3.10.8 | 17.8 dB(A) | 03 | X=35.62 | Extract Air | Y=16.05 | Cooling return

# IfcFlowTerminal: LF-090203-066 (4)
In: 00 Ground floor
Type - Description: Fluorescent batten fitting direct indirect 2x28 W T5; ApplicableOccurrence: Surface mounted luminaires; PredefinedType: DIRECTIONSOURCE
Type - Pset_ManufacturerTypeInformation - ArticleNumber: LF-090203-066; ModelReference: Fluorescent batten fitting direct indirect 2x28 W T5; Manufacturer: DDS
Type - Pset_LightFixtureTypeCommon - MaintenanceFactor: 1.25; NumberOfSources: 2; TotalWattage: 56 W
Type - Pset_ElectricalDeviceCommon - HasProtectiveEarth: no
Material: IFC Building Material
Pset_DDS - Mtg. Below Ceiling ref Top: Top= 0.52m FCL; Power tekst: 28.00; Above Sea Level ref. Center: NN=2.58 m; Voltage loss: 100.0%; Mtg. Above Slab ref Bottom: Edge= 2.78m SSL; Manufacturer: DDS; Room number: 00.19; Room tekst: Office; Model Number: Dra.no: 1; Layer number: 8; Product: Fluorescent batten fitting direct indirect 2x28 W T5; Mtg. above Finished Floor ref Center: CC= 2.78m FFB; Project name: OpenBIM; Number of Tube Text: 2; Mounting Height: 2.78 m; Floor number: Storey: 2; Mtg. Above Slab ref Center: CC= 2.78m SSL; Above Sea Level ref. Bottom: NNUK=2.58 m; Voltage: 0V; Product Number: LF-090203-066; Mtg. Below Ceiling ref Center: CC= 0.52m FCL; Building Part: Building: 0; Cable length to central: 0.000 m
Pset_DistributionFlowElementCommon - Reference: LF-090203-066
Pset_ElectricalCostData - ProductCodeValue: WT1.3; Location: NOR; ProductCodeName: NS3420; SystemCodeValue: 8; CostCodeValue: F-090203-066; CostCodeName: Eldata Kode; SystemCodeName: NS3451
AC_Pset_RenovationAndPhasing - Renovation Status: Existing
Name | Y | X
Fittings | Y=11.73 | X=8.89
Fittings | Y=14.02 | X=8.89
Fittings | Y=11.73 | X=6.49
Fittings | Y=14.02 | X=6.49

# IfcFlowTerminal: LF-090203-067 (43)
Type - Description: Fluorescent batten fitting direct indirect 2x35 W T5; ApplicableOccurrence: Surface mounted luminaires; PredefinedType: DIRECTIONSOURCE
Type - Pset_ManufacturerTypeInformation - ArticleNumber: LF-090203-067; ModelReference: Fluorescent batten fitting direct indirect 2x35 W T5; Manufacturer: DDS
Type - Pset_LightFixtureTypeCommon - MaintenanceFactor: 1.25; NumberOfSources: 2; TotalWattage: 70 W
Type - Pset_ElectricalDeviceCommon - HasProtectiveEarth: no
Material: IFC Building Material
Pset_DDS - Voltage loss: 100.0%; Manufacturer: DDS; Product: Fluorescent batten fitting direct indirect 2x35 W T5; Layer number: 8; Project name: OpenBIM; Number of Tube Text: 2; Mounting Height: 2.78 m; Voltage: 0V; Product Number: LF-090203-067; Building Part: Building: 0; Cable length to central: 0.000 m; Power tekst: 35.00
Pset_ElectricalCostData - CostCodeValue: F-090203-067; ProductCodeValue: WT1.3; Location: NOR; ProductCodeName: NS3420; SystemCodeValue: 8; CostCodeName: Eldata Kode; SystemCodeName: NS3451
Pset_DistributionFlowElementCommon - Reference: LF-090203-067
AC_Pset_RenovationAndPhasing - Renovation Status: Existing
Name | In | Above Sea Level ref. Center | Mtg. Below Ceiling ref Top | Mtg. Below Ceiling ref Center | Mtg. above Finished Floor ref Center | Mtg. Above Slab ref Center | X | Room tekst | Model Number | Room number | Floor number | Above Sea Level ref. Bottom | Mtg. Above Slab ref Bottom | Y
Fittings | 00 Ground floor | NN=2.58 m | Top= 0.40m FCL | CC= 0.40m FCL | CC= 2.90m FFB | CC= 2.90m SSL | X=36.27 | Office | Dra.no: 1 | 00.23 | Storey: 2 | NNUK=2.58 m | Edge= 2.90m SSL | Y=15.48
Fittings | 00 Ground floor | NN=2.58 m | Top= 0.40m FCL | CC= 0.40m FCL | CC= 2.90m FFB | CC= 2.90m SSL | X=34.44 | Office | Dra.no: 1 | 00.23 | Storey: 2 | NNUK=2.58 m | Edge= 2.90m SSL | Y=15.48
Fittings | 00 Ground floor | NN=2.58 m | Top= 0.52m FCL | CC= 0.52m FCL | CC= 2.78m FFB | CC= 2.78m SSL | X=11.25 | Storage | Dra.no: 1 | 00.13 | Storey: 2 | NNUK=2.58 m | Edge= 2.78m SSL | Y=11.35
Fittings | 00 Ground floor | NN=2.58 m | Top= 0.52m FCL | CC= 0.52m FCL | CC= 2.78m FFB | CC= 2.78m SSL | X=11.25 | Storage | Dra.no: 1 | 00.13 | Storey: 2 | NNUK=2.58 m | Edge= 2.78m SSL | Y=12.88
Fittings | 00 Ground floor | NN=2.58 m | Top= 0.52m FCL | CC= 0.52m FCL | CC= 2.78m FFB | CC= 2.78m SSL | X=11.25 | Storage | Dra.no: 1 | 00.13 | Storey: 2 | NNUK=2.58 m | Edge= 2.78m SSL | Y=14.40
Fittings | 00 Ground floor | NN=2.58 m | Top= 0.52m FCL | CC= 0.52m FCL | CC= 2.78m FFB | CC= 2.78m SSL | X=11.25 | Office | Dra.no: 1 | 00.20 | Storey: 2 | NNUK=2.58 m | Edge= 2.78m SSL | Y=21.05
Fittings | 00 Ground floor | NN=2.58 m | Top= 0.52m FCL | CC= 0.52m FCL | CC= 2.78m FFB | CC= 2.78m SSL | X=9.07 | Office | Dra.no: 1 | 00.20 | Storey: 2 | NNUK=2.58 m | Edge= 2.78m SSL | Y=21.05
Fittings | 00 Ground floor | NN=2.58 m | Top= 0.52m FCL | CC= 0.52m FCL | CC= 2.78m FFB | CC= 2.78m SSL | X=11.25 | Office | Dra.no: 1 | 00.20 | Storey: 2 | NNUK=2.58 m | Edge= 2.78m SSL | Y=18.42
Fittings | 00 Ground floor | NN=2.58 m | Top= 0.52m FCL | CC= 0.52m FCL | CC= 2.78m FFB | CC= 2.78m SSL | X=9.07 | Office | Dra.no: 1 | 00.20 | Storey: 2 | NNUK=2.58 m | Edge= 2.78m SSL | Y=18.42
Fittings | 00 Ground floor | NN=2.58 m | Top= 0.52m FCL | CC= 0.52m FCL | CC= 2.78m FFB | CC= 2.78m SSL | X=15.73 | Office | Dra.no: 1 | 00.21 | Storey: 2 | NNUK=2.58 m | Edge= 2.78m SSL | Y=21.05
Fittings | 00 Ground floor | NN=2.58 m | Top= 0.52m FCL | CC= 0.52m FCL | CC= 2.78m FFB | CC= 2.78m SSL | X=13.52 | Office | Dra.no: 1 | 00.21 | Storey: 2 | NNUK=2.58 m | Edge= 2.78m SSL | Y=21.05
Fittings | 00 Ground floor | NN=2.58 m | Top= 0.52m FCL | CC= 0.52m FCL | CC= 2.78m FFB | CC= 2.78m SSL | X=15.73 | Office | Dra.no: 1 | 00.21 | Storey: 2 | NNUK=2.58 m | Edge= 2.78m SSL | Y=18.42
Fittings | 00 Ground floor | NN=2.58 m | Top= 0.40m FCL | CC= 0.40m FCL | CC= 2.90m FFB | CC= 2.90m SSL | X=38.10 | Office | Dra.no: 1 | 00.23 | Storey: 2 | NNUK=2.58 m | Edge= 2.90m SSL | Y=15.48
Fittings | 00 Ground floor | NN=2.58 m | Top= 0.40m FCL | CC= 0.40m FCL | CC= 2.90m FFB | CC= 2.90m SSL | X=39.92 | Office | Dra.no: 1 | 00.23 | Storey: 2 | NNUK=2.58 m | Edge= 2.90m SSL | Y=15.48
Fittings | 00 Ground floor | NN=2.58 m | Top= 0.40m FCL | CC= 0.40m FCL | CC= 2.90m FFB | CC= 2.90m SSL | X=34.44 | Office | Dra.no: 1 | 00.23 | Storey: 2 | NNUK=2.58 m | Edge= 2.90m SSL | Y=18.23
Fittings | 00 Ground floor | NN=2.58 m | Top= 0.40m FCL | CC= 0.40m FCL | CC= 2.90m FFB | CC= 2.90m SSL | X=36.27 | Office | Dra.no: 1 | 00.23 | Storey: 2 | NNUK=2.58 m | Edge= 2.90m SSL | Y=18.23
Fittings | 00 Ground floor | NN=2.58 m | Top= 0.40m FCL | CC= 0.40m FCL | CC= 2.90m FFB | CC= 2.90m SSL | X=38.10 | Office | Dra.no: 1 | 00.23 | Storey: 2 | NNUK=2.58 m | Edge= 2.90m SSL | Y=18.23
Fittings | 00 Ground floor | NN=2.58 m | Top= 0.40m FCL | CC= 0.40m FCL | CC= 2.90m FFB | CC= 2.90m SSL | X=39.92 | Office | Dra.no: 1 | 00.23 | Storey: 2 | NNUK=2.58 m | Edge= 2.90m SSL | Y=18.23
Fittings | 00 Ground floor | NN=2.58 m | Top= 0.40m FCL | CC= 0.40m FCL | CC= 2.90m FFB | CC= 2.90m SSL | X=34.44 | Office | Dra.no: 1 | 00.23 | Storey: 2 | NNUK=2.58 m | Edge= 2.90m SSL | Y=20.98
Fittings | 00 Ground floor | NN=2.58 m | Top= 0.40m FCL | CC= 0.40m FCL | CC= 2.90m FFB | CC= 2.90m SSL | X=36.27 | Office | Dra.no: 1 | 00.23 | Storey: 2 | NNUK=2.58 m | Edge= 2.90m SSL | Y=20.98
Fittings | 00 Ground floor | NN=2.58 m | Top= 0.40m FCL | CC= 0.40m FCL | CC= 2.90m FFB | CC= 2.90m SSL | X=38.10 | Office | Dra.no: 1 | 00.23 | Storey: 2 | NNUK=2.58 m | Edge= 2.90m SSL | Y=20.98
Fittings | 00 Ground floor | NN=2.58 m | Top= 0.40m FCL | CC= 0.40m FCL | CC= 2.90m FFB | CC= 2.90m SSL | X=39.92 | Office | Dra.no: 1 | 00.23 | Storey: 2 | NNUK=2.58 m | Edge= 2.90m SSL | Y=20.98
Fittings | 00 Ground floor | NN=2.58 m | Top= 0.52m FCL | CC= 0.52m FCL | CC= 2.78m FFB | CC= 2.78m SSL | X=13.52 | Office | Dra.no: 1 | 00.21 | Storey: 2 | NNUK=2.58 m | Edge= 2.78m SSL | Y=18.42
Fittings | 00 Ground floor | NN=2.58 m | Top= 0.52m FCL | CC= 0.52m FCL | CC= 2.78m FFB | CC= 2.78m SSL | X=20.23 | Office | Dra.no: 1 | 001 | Storey: 2 | NNUK=2.58 m | Edge= 2.78m SSL | Y=21.05
Fittings | 00 Ground floor | NN=2.58 m | Top= 0.52m FCL | CC= 0.52m FCL | CC= 2.78m FFB | CC= 2.78m SSL | X=18.02 | Office | Dra.no: 1 | 001 | Storey: 2 | NNUK=2.58 m | Edge= 2.78m SSL | Y=21.05
Fittings | 00 Ground floor | NN=2.58 m | Top= 0.52m FCL | CC= 0.52m FCL | CC= 2.78m FFB | CC= 2.78m SSL | X=20.23 | Office | Dra.no: 1 | 001 | Storey: 2 | NNUK=2.58 m | Edge= 2.78m SSL | Y=18.42
Fittings | 00 Ground floor | NN=2.58 m | Top= 0.52m FCL | CC= 0.52m FCL | CC= 2.78m FFB | CC= 2.78m SSL | X=18.02 | Office | Dra.no: 1 | 001 | Storey: 2 | NNUK=2.58 m | Edge= 2.78m SSL | Y=18.42
Fittings | 01 First floor | NN=6.08 m | Top= 0.40m FCL | CC= 0.40m FCL | CC= 2.90m FFB | CC= 2.90m SSL | X=11.25 | Office | Dra.no: 2 | 01.18 | Storey: 3 | NNUK=6.08 m | Edge= 2.90m SSL | Y=18.42
Fittings | 01 First floor | NN=6.08 m | Top= 0.40m FCL | CC= 0.40m FCL | CC= 2.90m FFB | CC= 2.90m SSL | X=9.07 | Office | Dra.no: 2 | 01.18 | Storey: 3 | NNUK=6.08 m | Edge= 2.90m SSL | Y=18.42
Fittings | 01 First floor | NN=6.08 m | Top= 0.40m FCL | CC= 0.40m FCL | CC= 2.90m FFB | CC= 2.90m SSL | X=15.73 | Office | Dra.no: 2 | 01.20 | Storey: 3 | NNUK=6.08 m | Edge= 2.90m SSL | Y=21.05
Fittings | 01 First floor | NN=6.08 m | Top= 0.40m FCL | CC= 0.40m FCL | CC= 2.90m FFB | CC= 2.90m SSL | X=9.07 | Office | Dra.no: 2 | 01.18 | Storey: 3 | NNUK=6.08 m | Edge= 2.90m SSL | Y=21.05
Fittings | 01 First floor | NN=6.08 m | Top= 0.40m FCL | CC= 0.40m FCL | CC= 2.90m FFB | CC= 2.90m SSL | X=11.25 | Office | Dra.no: 2 | 01.18 | Storey: 3 | NNUK=6.08 m | Edge= 2.90m SSL | Y=21.05
Fittings | 01 First floor | NN=6.08 m | Top= 0.40m FCL | CC= 0.40m FCL | CC= 2.90m FFB | CC= 2.90m SSL | X=13.52 | Office | Dra.no: 2 | 01.20 | Storey: 3 | NNUK=6.08 m | Edge= 2.90m SSL | Y=21.05
Fittings | 01 First floor | NN=6.08 m | Top= 0.40m FCL | CC= 0.40m FCL | CC= 2.90m FFB | CC= 2.90m SSL | X=15.73 | Office | Dra.no: 2 | 01.20 | Storey: 3 | NNUK=6.08 m | Edge= 2.90m SSL | Y=18.42
Fittings | 01 First floor | NN=6.08 m | Top= 0.40m FCL | CC= 0.40m FCL | CC= 2.90m FFB | CC= 2.90m SSL | X=13.52 | Office | Dra.no: 2 | 01.20 | Storey: 3 | NNUK=6.08 m | Edge= 2.90m SSL | Y=18.42
Fittings | 01 First floor | NN=6.08 m | Top= 0.40m FCL | CC= 0.40m FCL | CC= 2.90m FFB | CC= 2.90m SSL | X=20.23 | Office | Dra.no: 2 | 01.19 | Storey: 3 | NNUK=6.08 m | Edge= 2.90m SSL | Y=21.05
Fittings | 01 First floor | NN=6.08 m | Top= 0.40m FCL | CC= 0.40m FCL | CC= 2.90m FFB | CC= 2.90m SSL | X=18.02 | Office | Dra.no: 2 | 01.19 | Storey: 3 | NNUK=6.08 m | Edge= 2.90m SSL | Y=21.05
Fittings | 01 First floor | NN=6.08 m | Top= 0.40m FCL | CC= 0.40m FCL | CC= 2.90m FFB | CC= 2.90m SSL | X=20.23 | Office | Dra.no: 2 | 01.19 | Storey: 3 | NNUK=6.08 m | Edge= 2.90m SSL | Y=18.42
Fittings | 01 First floor | NN=6.08 m | Top= 0.40m FCL | CC= 0.40m FCL | CC= 2.90m FFB | CC= 2.90m SSL | X=18.02 | Office | Dra.no: 2 | 01.19 | Storey: 3 | NNUK=6.08 m | Edge= 2.90m SSL | Y=18.42
Fittings | 01 First floor | NN=6.08 m | Top= 0.65m FCL | CC= 0.65m FCL | CC= 2.65m FFB | CC= 2.65m SSL | X=8.89 | Office | Dra.no: 2 | 01.17 | Storey: 3 | NNUK=6.08 m | Edge= 2.65m SSL | Y=11.73
Fittings | 01 First floor | NN=6.08 m | Top= 0.65m FCL | CC= 0.65m FCL | CC= 2.65m FFB | CC= 2.65m SSL | X=8.89 | Office | Dra.no: 2 | 01.17 | Storey: 3 | NNUK=6.08 m | Edge= 2.65m SSL | Y=14.02
Fittings | 01 First floor | NN=6.08 m | Top= 0.65m FCL | CC= 0.65m FCL | CC= 2.65m FFB | CC= 2.65m SSL | X=6.49 | Office | Dra.no: 2 | 01.17 | Storey: 3 | NNUK=6.08 m | Edge= 2.65m SSL | Y=11.73
Fittings | 01 First floor | NN=6.08 m | Top= 0.65m FCL | CC= 0.65m FCL | CC= 2.65m FFB | CC= 2.65m SSL | X=6.49 | Office | Dra.no: 2 | 01.17 | Storey: 3 | NNUK=6.08 m | Edge= 2.65m SSL | Y=14.02

# IfcFlowTerminal: LF-090203-068 (16)
In: 01 First floor
Type - Description: Fluorescent batten fitting direct indirect 2x49 W T5; ApplicableOccurrence: Surface mounted luminaires; PredefinedType: DIRECTIONSOURCE
Type - Pset_ManufacturerTypeInformation - ArticleNumber: LF-090203-068; ModelReference: Fluorescent batten fitting direct indirect 2x49 W T5; Manufacturer: DDS
Type - Pset_LightFixtureTypeCommon - MaintenanceFactor: 1.25; NumberOfSources: 2; TotalWattage: 98 W
Type - Pset_ElectricalDeviceCommon - HasProtectiveEarth: no
Material: IFC Building Material
Pset_DDS - Voltage loss: 100.0%; Product: Fluorescent batten fitting direct indirect 2x49 W T5; Manufacturer: DDS; Above Sea Level ref. Bottom: NNUK=6.08 m; Power tekst: 49.00; Model Number: Dra.no: 2; Mtg. Below Ceiling ref Top: Top= 0.65m FCL; Layer number: 8; Project name: OpenBIM; Number of Tube Text: 2; Mounting Height: 2.78 m; Floor number: Storey: 3; Mtg. above Finished Floor ref Center: CC= 2.65m FFB; Mtg. Above Slab ref Bottom: Edge= 2.65m SSL; Above Sea Level ref. Center: NN=6.08 m; Mtg. Below Ceiling ref Center: CC= 0.65m FCL; Voltage: 0V; Product Number: LF-090203-068; Mtg. Above Slab ref Center: CC= 2.65m SSL; Building Part: Building: 0; Cable length to central: 0.000 m
Pset_ElectricalCostData - ProductCodeValue: WT1.3; CostCodeValue: F-090203-068; Location: NOR; ProductCodeName: NS3420; SystemCodeValue: 8; CostCodeName: Eldata Kode; SystemCodeName: NS3451
Pset_DistributionFlowElementCommon - Reference: LF-090203-068
AC_Pset_RenovationAndPhasing - Renovation Status: Existing
Name | Room number | Y | Room tekst | X
Fittings | 01.03 | Y=8.26 | Restaurant | X=25.92
Fittings | 01.03 | Y=8.26 | Restaurant | X=28.93
Fittings | 01.03 | Y=8.26 | Restaurant | X=22.92
Fittings | 01.03 | Y=8.26 | Restaurant | X=19.92
Fittings | 01.03 | Y=8.26 | Restaurant | X=16.91
Fittings | 01.03 | Y=8.26 | Restaurant | X=31.93
Fittings | 01.03 | Y=10.81 | Restaurant | X=13.91
Fittings | 01.03 | Y=10.81 | Restaurant | X=16.91
Fittings | 01.03 | Y=10.81 | Restaurant | X=19.92
Fittings | 01.03 | Y=10.81 | Restaurant | X=22.92
Fittings | 01.03 | Y=10.81 | Restaurant | X=25.92
Fittings | 01.12 | Y=11.73 | Storage | X=11.25
Fittings | 01.12 | Y=14.02 | Storage | X=11.25
Fittings | 01.03 | Y=8.26 | Restaurant | X=13.91
Fittings | 01.03 | Y=10.81 | Restaurant | X=28.93
Fittings | 01.03 | Y=10.81 | Restaurant | X=31.93

# IfcFlowTerminal: LF-090203-069 (6)
In: 00 Ground floor
Type - Description: Fluorescent batten fitting direct indirect 2x54 W T5; ApplicableOccurrence: Surface mounted luminaires; PredefinedType: DIRECTIONSOURCE
Type - Pset_ManufacturerTypeInformation - ArticleNumber: LF-090203-069; ModelReference: Fluorescent batten fitting direct indirect 2x54 W T5; Manufacturer: DDS
Type - Pset_LightFixtureTypeCommon - MaintenanceFactor: 1.25; NumberOfSources: 2; TotalWattage: 108 W
Type - Pset_ElectricalDeviceCommon - HasProtectiveEarth: no
Material: IFC Building Material
Pset_DDS - Above Sea Level ref. Center: NN=2.58 m; Voltage loss: 100.0%; Manufacturer: DDS; Model Number: Dra.no: 1; Layer number: 8; Project name: OpenBIM; Number of Tube Text: 2; Mounting Height: 2.78 m; Floor number: Storey: 2; Power tekst: 54.00; Above Sea Level ref. Bottom: NNUK=2.58 m; Voltage: 0V; Product Number: LF-090203-069; Room tekst: Director office; Building Part: Building: 0; Cable length to central: 0.000 m; Product: Fluorescent batten fitting direct indirect 2x54 W T5
Pset_ElectricalCostData - ProductCodeValue: WT1.3; Location: NOR; ProductCodeName: NS3420; SystemCodeValue: 8; CostCodeValue: F-090203-069; CostCodeName: Eldata Kode; SystemCodeName: NS3451
Pset_DistributionFlowElementCommon - Reference: LF-090203-069
AC_Pset_RenovationAndPhasing - Renovation Status: Existing
Name | Y | Mtg. Below Ceiling ref Top | Room number | Mtg. above Finished Floor ref Center | Mtg. Above Slab ref Bottom | Mtg. Below Ceiling ref Center | X | Mtg. Above Slab ref Center
Fittings | Y=7.87 | Top= 0.65m FCL | 00.25 | CC= 2.65m FFB | Edge= 2.65m SSL | CC= 0.65m FCL | X=32.57 | CC= 2.65m SSL
Fittings | Y=7.87 | Top= 0.65m FCL | 00.25 | CC= 2.65m FFB | Edge= 2.65m SSL | CC= 0.65m FCL | X=35.20 | CC= 2.65m SSL
Fittings | Y=9.62 | Top= 0.65m FCL | 00.25 | CC= 2.65m FFB | Edge= 2.65m SSL | CC= 0.65m FCL | X=32.57 | CC= 2.65m SSL
Fittings | Y=9.62 | Top= 0.65m FCL | 00.25 | CC= 2.65m FFB | Edge= 2.65m SSL | CC= 0.65m FCL | X=35.20 | CC= 2.65m SSL
Fittings | Y=7.87 | Top= 0.40m FCL | 00.24 | CC= 2.90m FFB | Edge= 2.90m SSL | CC= 0.40m FCL | X=38.71 | CC= 2.90m SSL
Fittings | Y=9.62 | Top= 0.40m FCL | 00.24 | CC= 2.90m FFB | Edge= 2.90m SSL | CC= 0.40m FCL | X=38.71 | CC= 2.90m SSL

# IfcFlowTerminal: SK-110726-001 (24)
Type - Description: Flush mounted socket double; ApplicableOccurrence: Flush mounted sockets; PredefinedType: POWEROUTLET
Type - Pset_ManufacturerTypeInformation - ArticleNumber: SK-110726-001; ModelReference: Flush mounted socket double; Manufacturer: DDS
Type - Pset_OutletTypeCommon - IsPluggableOutlet: yes
Type - Pset_ElectricalDeviceCommon - HasProtectiveEarth: yes; NumberOfPoles: 3
Material: IFC Building Material
Pset_DDS - Product: Flush mounted socket double; Mounting Height: 0.30 m; Voltage loss: 100.0%; Manufacturer: DDS; Room tekst: Office; Product Number: SK-110726-001; Layer number: 4; Project name: OpenBIM; Number of Poles: 3; Current Rating: 16.00; Voltage: 0V; PE Text: PE; Building Part: Building: 0; Cable length to central: 0.000 m
Pset_DistributionFlowElementCommon - Reference: SK-110726-001
Pset_ElectricalCostData - ProductCodeValue: WL1.2; CostCodeValue: K-110726-001; Location: NOR; ProductCodeName: NS3420; SystemCodeValue: 4; CostCodeName: Eldata Kode; SystemCodeName: NS3451
AC_Pset_RenovationAndPhasing - Renovation Status: Existing
Name | In | Mtg. Below Ceiling ref Center | Above Sea Level ref. Center | Y | X | Mtg. above Finished Floor ref Center | Mtg. Above Slab ref Center | Model Number | Above Sea Level ref. Bottom | Room number | Floor number | Mtg. Below Ceiling ref Top | Mtg. Above Slab ref Bottom
Socket | 00 Ground floor | CC= 3.00m FCL | NN=0.10 m | Y=17.13 | X=9.75 | CC= 0.30m FFB | CC= 0.30m SSL | Dra.no: 1 | NNUK=0.10 m | 00.20 | Storey: 2 | Top= 3.00m FCL | Edge= 0.30m SSL
Socket | 00 Ground floor | CC= 3.00m FCL | NN=0.10 m | Y=17.13 | X=12.10 | CC= 0.30m FFB | CC= 0.30m SSL | Dra.no: 1 | NNUK=0.10 m | 00.20 | Storey: 2 | Top= 3.00m FCL | Edge= 0.30m SSL
Socket | 00 Ground floor | CC= 3.00m FCL | NN=0.10 m | Y=22.34 | X=12.18 | CC= 0.30m FFB | CC= 0.30m SSL | Dra.no: 1 | NNUK=0.10 m | 00.20 | Storey: 2 | Top= 3.00m FCL | Edge= 0.30m SSL
Socket | 00 Ground floor | CC= 3.00m FCL | NN=0.10 m | Y=22.34 | X=8.18 | CC= 0.30m FFB | CC= 0.30m SSL | Dra.no: 1 | NNUK=0.10 m | 00.20 | Storey: 2 | Top= 3.00m FCL | Edge= 0.30m SSL
Socket | 00 Ground floor | CC= 3.00m FCL | NN=0.10 m | Y=22.34 | X=17.17 | CC= 0.30m FFB | CC= 0.30m SSL | Dra.no: 1 | NNUK=0.10 m | 001 | Storey: 2 | Top= 3.00m FCL | Edge= 0.30m SSL
Socket | 00 Ground floor | CC= 3.00m FCL | NN=0.10 m | Y=22.34 | X=21.16 | CC= 0.30m FFB | CC= 0.30m SSL | Dra.no: 1 | NNUK=0.10 m | 001 | Storey: 2 | Top= 3.00m FCL | Edge= 0.30m SSL
Socket | 00 Ground floor | CC= 3.00m FCL | NN=0.10 m | Y=17.13 | X=21.08 | CC= 0.30m FFB | CC= 0.30m SSL | Dra.no: 1 | NNUK=0.10 m | 001 | Storey: 2 | Top= 3.00m FCL | Edge= 0.30m SSL
Socket | 00 Ground floor | CC= 3.00m FCL | NN=0.10 m | Y=17.13 | X=18.73 | CC= 0.30m FFB | CC= 0.30m SSL | Dra.no: 1 | NNUK=0.10 m | 001 | Storey: 2 | Top= 3.00m FCL | Edge= 0.30m SSL
Socket | 00 Ground floor | CC= 3.00m FCL | NN=0.10 m | Y=22.34 | X=12.67 | CC= 0.30m FFB | CC= 0.30m SSL | Dra.no: 1 | NNUK=0.10 m | 00.21 | Storey: 2 | Top= 3.00m FCL | Edge= 0.30m SSL
Socket | 00 Ground floor | CC= 3.00m FCL | NN=0.10 m | Y=22.34 | X=16.66 | CC= 0.30m FFB | CC= 0.30m SSL | Dra.no: 1 | NNUK=0.10 m | 00.21 | Storey: 2 | Top= 3.00m FCL | Edge= 0.30m SSL
Socket | 00 Ground floor | CC= 3.00m FCL | NN=0.10 m | Y=17.13 | X=16.58 | CC= 0.30m FFB | CC= 0.30m SSL | Dra.no: 1 | NNUK=0.10 m | 00.21 | Storey: 2 | Top= 3.00m FCL | Edge= 0.30m SSL
Socket | 00 Ground floor | CC= 3.00m FCL | NN=0.10 m | Y=17.13 | X=14.23 | CC= 0.30m FFB | CC= 0.30m SSL | Dra.no: 1 | NNUK=0.10 m | 00.21 | Storey: 2 | Top= 3.00m FCL | Edge= 0.30m SSL
Socket | 01 First floor | CC= 2.88m FCL | NN=3.60 m | Y=17.13 | X=9.75 | CC= 0.42m FFB | CC= 0.42m SSL | Dra.no: 2 | NNUK=3.60 m | 01.18 | Storey: 3 | Top= 2.88m FCL | Edge= 0.42m SSL
Socket | 01 First floor | CC= 2.88m FCL | NN=3.60 m | Y=17.13 | X=12.10 | CC= 0.42m FFB | CC= 0.42m SSL | Dra.no: 2 | NNUK=3.60 m | 01.18 | Storey: 3 | Top= 2.88m FCL | Edge= 0.42m SSL
Socket | 01 First floor | CC= 2.88m FCL | NN=3.60 m | Y=22.34 | X=12.18 | CC= 0.42m FFB | CC= 0.42m SSL | Dra.no: 2 | NNUK=3.60 m | 01.18 | Storey: 3 | Top= 2.88m FCL | Edge= 0.42m SSL
Socket | 01 First floor | CC= 2.88m FCL | NN=3.60 m | Y=22.34 | X=8.18 | CC= 0.42m FFB | CC= 0.42m SSL | Dra.no: 2 | NNUK=3.60 m | 01.18 | Storey: 3 | Top= 2.88m FCL | Edge= 0.42m SSL
Socket | 01 First floor | CC= 2.88m FCL | NN=3.60 m | Y=22.34 | X=17.17 | CC= 0.42m FFB | CC= 0.42m SSL | Dra.no: 2 | NNUK=3.60 m | 01.19 | Storey: 3 | Top= 2.88m FCL | Edge= 0.42m SSL
Socket | 01 First floor | CC= 2.88m FCL | NN=3.60 m | Y=22.34 | X=21.16 | CC= 0.42m FFB | CC= 0.42m SSL | Dra.no: 2 | NNUK=3.60 m | 01.19 | Storey: 3 | Top= 2.88m FCL | Edge= 0.42m SSL
Socket | 01 First floor | CC= 2.88m FCL | NN=3.60 m | Y=17.13 | X=21.08 | CC= 0.42m FFB | CC= 0.42m SSL | Dra.no: 2 | NNUK=3.60 m | 01.19 | Storey: 3 | Top= 2.88m FCL | Edge= 0.42m SSL
Socket | 01 First floor | CC= 2.88m FCL | NN=3.60 m | Y=17.13 | X=18.73 | CC= 0.42m FFB | CC= 0.42m SSL | Dra.no: 2 | NNUK=3.60 m | 01.19 | Storey: 3 | Top= 2.88m FCL | Edge= 0.42m SSL
Socket | 01 First floor | CC= 2.88m FCL | NN=3.60 m | Y=22.34 | X=12.67 | CC= 0.42m FFB | CC= 0.42m SSL | Dra.no: 2 | NNUK=3.60 m | 01.20 | Storey: 3 | Top= 2.88m FCL | Edge= 0.42m SSL
Socket | 01 First floor | CC= 2.88m FCL | NN=3.60 m | Y=22.34 | X=16.66 | CC= 0.42m FFB | CC= 0.42m SSL | Dra.no: 2 | NNUK=3.60 m | 01.20 | Storey: 3 | Top= 2.88m FCL | Edge= 0.42m SSL
Socket | 01 First floor | CC= 2.88m FCL | NN=3.60 m | Y=17.13 | X=16.58 | CC= 0.42m FFB | CC= 0.42m SSL | Dra.no: 2 | NNUK=3.60 m | 01.20 | Storey: 3 | Top= 2.88m FCL | Edge= 0.42m SSL
Socket | 01 First floor | CC= 2.88m FCL | NN=3.60 m | Y=17.13 | X=14.23 | CC= 0.42m FFB | CC= 0.42m SSL | Dra.no: 2 | NNUK=3.60 m | 01.20 | Storey: 3 | Top= 2.88m FCL | Edge= 0.42m SSL

# IfcFlowTerminal: WC078A (10)
Type - Description: Wall WC concealed installation; ApplicableOccurrence: Urinal; PredefinedType: TOILETPAN
Type - Pset_ManufacturerTypeInformation - ArticleNumber: WC078A; ModelReference: Wall WC concealed installation; ModelLabel: Toilet; Manufacturer: DDS
Type - Pset_SanitaryTerminalTypeToiletPan - NominalLength: 541 mm; NominalWidth: 420 mm; NominalDepth: 440 mm
Material: IFC Building Material
Pset_DDS - Mounting Height: 0.00 m; Length: 541; Product: Wall WC concealed installation; Manufacturer: DDS; Width: 420; Room tekst: wc; Dimension DN: 420 mm; Layer number: 20; Project name: OpenBIM; Product Number: WC078A; Building Part: Building: 0
Pset_DistributionFlowElementCommon - Reference: WC078A
AC_Pset_RenovationAndPhasing - Renovation Status: Existing
Name | In | Mtg. Above Slab ref Center | Y | Mtg. Below Ceiling ref Top | Above Sea Level ref. Bottom | Room number | Mtg. Below Ceiling ref Center | Model Number | Above Sea Level ref. Center | Floor number | X | Mtg. Above Slab ref Bottom | Mtg. above Finished Floor ref Center
Urinal | 00 Ground floor | CC= 0.22m SSL | Y=13.05 | Top= 2.86m FCL | NNUK=-0.20 m | 00.10 | CC= 3.08m FCL | Dra.no: 1 | NN=0.02 m | Storey: 2 | X=22.35 | Edge= 0.00m SSL | CC= 0.22m FFB
Urinal | 00 Ground floor | CC= 0.22m SSL | Y=12.53 | Top= 2.86m FCL | NNUK=-0.20 m | 00.06 | CC= 3.08m FCL | Dra.no: 1 | NN=0.02 m | Storey: 2 | X=18.80 | Edge= 0.00m SSL | CC= 0.22m FFB
Urinal | 00 Ground floor | CC= 0.22m SSL | Y=13.61 | Top= 2.86m FCL | NNUK=-0.20 m | 00.08 | CC= 3.08m FCL | Dra.no: 1 | NN=0.02 m | Storey: 2 | X=18.80 | Edge= 0.00m SSL | CC= 0.22m FFB
Urinal | 00 Ground floor | CC= 0.22m SSL | Y=14.17 | Top= 2.86m FCL | NNUK=-0.20 m | 00.09 | CC= 3.08m FCL | Dra.no: 1 | NN=0.02 m | Storey: 2 | X=22.34 | Edge= 0.00m SSL | CC= 0.22m FFB
Urinal | 00 Ground floor | CC= 0.22m SSL | Y=14.67 | Top= 2.86m FCL | NNUK=-0.20 m | 00.07 | CC= 3.08m FCL | Dra.no: 1 | NN=0.02 m | Storey: 2 | X=18.80 | Edge= 0.00m SSL | CC= 0.22m FFB
Urinal | 01 First floor | CC= 0.09m SSL | Y=14.67 | Top= 2.99m FCL | NNUK=3.30 m | 01.08 | CC= 3.21m FCL | Dra.no: 2 | NN=3.52 m | Storey: 3 | X=18.80 | Edge= -0.13m SSL | CC= 0.09m FFB
Urinal | 01 First floor | CC= 0.09m SSL | Y=13.61 | Top= 2.99m FCL | NNUK=3.30 m | 01.09 | CC= 3.21m FCL | Dra.no: 2 | NN=3.52 m | Storey: 3 | X=18.80 | Edge= -0.13m SSL | CC= 0.09m FFB
Urinal | 01 First floor | CC= 0.09m SSL | Y=12.53 | Top= 2.99m FCL | NNUK=3.30 m | 01.07 | CC= 3.21m FCL | Dra.no: 2 | NN=3.52 m | Storey: 3 | X=18.80 | Edge= -0.13m SSL | CC= 0.09m FFB
Urinal | 01 First floor | CC= 0.09m SSL | Y=13.05 | Top= 2.99m FCL | NNUK=3.30 m | 01.10 | CC= 3.21m FCL | Dra.no: 2 | NN=3.52 m | Storey: 3 | X=22.36 | Edge= -0.13m SSL | CC= 0.09m FFB
Urinal | 01 First floor | CC= 0.09m SSL | Y=14.17 | Top= 2.99m FCL | NNUK=3.30 m | 01.11 | CC= 3.21m FCL | Dra.no: 2 | NN=3.52 m | Storey: 3 | X=22.35 | Edge= -0.13m SSL | CC= 0.09m FFB
