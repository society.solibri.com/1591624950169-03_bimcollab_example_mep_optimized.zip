Properties of the parts of a building model (IFC2X3), part 2 of 14

# IfcFlowFitting: BE3000015090 (106)
Name | In | Abs. pressure | Mounting Height | Velocity | Mtg. Below Ceiling ref Center | Main string number | Above Sea Level ref. Bottom | Mtg. above Finished Floor ref Center | Insulation product text | Ins thickness | Mtg. Above Slab ref Center | Insulation product number | Part number | Y | System Name | Model Number | Layer number | Sub string number | Flow (l/s) | Flow (l/h) | Flow (m\X\B3/h) | Floor number | Mtg. Above Slab ref Bottom | Above Sea Level ref. Center | Room tekst | Room number | Rotation | Pressure drop | Mtg. Below Ceiling ref Top | Medium | X | Group
2.3.1 | 00 Ground floor | 148404.7 Pa | 3.18 m | 1.67 m/s | CC= 0.32m FCL | 02 | NNUK=2.96 m | CC= 3.18m FFB | Pipe insulation | ins= 9.000000 mm | CC= 3.18m SSL | ZP150/915 | .001 | Y=11.09 |  | Dra.no: 1 | 3 | .0003 | 0.28 l/s | 1008.000004 l/h | 1.0 m\X\B3/h | Storey: 2 | Edge= 3.17m SSL | NN=2.98 m | Entrance | 00.01 | 0.000000 | 9386 | Top= 0.32m FCL | Hotwater | X=21.91 | Hotwater
2.3.2 | 00 Ground floor | 135820.7 Pa | 3.18 m | 0.53 m/s | CC= 0.12m FCL | 02 | NNUK=2.96 m | CC= 3.18m FFB | Pipe insulation | ins= 9.000000 mm | CC= 3.18m SSL | ZP150/915 | .002 | Y=15.00 |  | Dra.no: 1 | 3 | .0003 | 0.28 l/s | 1008.000004 l/h | 1.0 m\X\B3/h | Storey: 2 | Edge= 3.17m SSL | NN=2.98 m | wc | 00.09 | 180.000000 | 9386 | Top= 0.12m FCL | Hotwater | X=23.11 | Hotwater
2.6.2 | 00 Ground floor | 0.0 Pa | 3.10 m | 0.00 m/s | CC= 0.08m FCL | 02 | NNUK=2.89 m | CC= 3.22m FFB |  | ins= 0.000000 mm | CC= 3.22m SSL |  | .002 | Y=16.85 | Cooling | Dra.no: 1 | 188 | .0006 | 0.00 l/s | 0.000000 l/h | 0.0 m\X\B3/h | Storey: 2 | Edge= 3.21m SSL | NN=2.90 m | Office | 00.23 | 359.982284 | 0 | Top= 0.07m FCL | Cooling Flow | X=38.67 | Cooling flow
2.6.3 | 00 Ground floor | 0.0 Pa | 3.10 m | 0.00 m/s | CC= 0.08m FCL | 02 | NNUK=2.89 m | CC= 3.22m FFB |  | ins= 0.000000 mm | CC= 3.22m SSL |  | .003 | Y=16.57 | Cooling | Dra.no: 1 | 188 | .0006 | 0.00 l/s | 0.000000 l/h | 0.0 m\X\B3/h | Storey: 2 | Edge= 3.21m SSL | NN=2.90 m | Office | 00.23 | 90.000000 | 0 | Top= 0.07m FCL | Cooling Flow | X=38.67 | Cooling flow
2.7.1 | 00 Ground floor | 134869.3 Pa | 3.18 m | 0.53 m/s | CC= 0.12m FCL | 02 | NNUK=2.96 m | CC= 3.18m FFB | Pipe insulation | ins= 9.000000 mm | CC= 3.18m SSL | ZP150/915 | .001 | Y=15.19 |  | Dra.no: 1 | 3 | .0007 | 0.07 l/s | 252.000001 l/h | 0.3 m\X\B3/h | Storey: 2 | Edge= 3.17m SSL | NN=2.98 m | wc | 00.09 | 90.000000 | 134869 | Top= 0.12m FCL | Hotwater | X=23.11 | Hotwater
2.7.2 | 00 Ground floor | 134869.3 Pa | 0.63 m | 0.53 m/s | CC= 2.67m FCL | 02 | NNUK=0.42 m | CC= 0.63m FFB | Pipe insulation | ins= 9.000000 mm | CC= 0.63m SSL | ZP150/915 | .002 | Y=15.19 |  | Dra.no: 1 | 3 | .0007 | 0.07 l/s | 252.000001 l/h | 0.3 m\X\B3/h | Storey: 2 | Edge= 0.62m SSL | NN=0.43 m | wc | 00.09 | 90.000000 | 134869 | Top= 2.66m FCL | Hotwater | X=23.11 | Hotwater
2.7.2 | 00 Ground floor | 0.0 Pa | 3.10 m | 0.00 m/s | CC= 0.08m FCL | 02 | NNUK=2.89 m | CC= 3.22m FFB | Pipe insulation | ins= 9.000000 mm | CC= 3.22m SSL | ZP150/915 | .002 | Y=16.57 | Cooling | Dra.no: 1 | 188 | .0007 | 0.00 l/s | 0.000000 l/h | 0.0 m\X\B3/h | Storey: 2 | Edge= 3.21m SSL | NN=2.90 m | Office | 00.23 | 180.000000 | 0 | Top= 0.07m FCL | Cooling Flow | X=35.55 | Cooling flow
3.2.0 | 00 Ground floor | 0.0 Pa | 3.00 m | 0.00 m/s | CC= 0.18m FCL | 03 | NNUK=2.79 m | CC= 3.12m FFB |  | ins= 0.000000 mm | CC= 3.12m SSL |  | .000 | Y=20.42 | Cooling | Dra.no: 1 | 189 | .0002 | 0.00 l/s | 0.000000 l/h | 0.0 m\X\B3/h | Storey: 2 | Edge= 3.11m SSL | NN=2.80 m | Office | 00.23 | 0.000000 | 0 | Top= 0.17m FCL | Cooling return | X=38.61 | Cooling return
3.2.0 | 00 Ground floor | 0.0 Pa | 3.00 m | 0.00 m/s | CC= 0.18m FCL | 03 | NNUK=2.79 m | CC= 3.12m FFB |  | ins= 0.000000 mm | CC= 3.12m SSL |  | .000 | Y=20.32 | Cooling | Dra.no: 1 | 189 | .0002 | 0.00 l/s | 0.000000 l/h | 0.0 m\X\B3/h | Storey: 2 | Edge= 3.11m SSL | NN=2.80 m | Office | 00.23 | 90.000000 | 0 | Top= 0.17m FCL | Cooling return | X=38.61 | Cooling return
3.2.2 | 00 Ground floor | 2413.1 Pa | 3.25 m | 0.32 m/s | CC= 0.18m FCL | 03 | NNUK=3.04 m | CC= 3.12m FFB | Pipe insulation | ins= 9.000000 mm | CC= 3.12m SSL | ZP150/915 | .002 | Y=11.33 |  | Dra.no: 1 | 4 | .0002 | 0.04 l/s | 151.334382 l/h | 0.2 m\X\B3/h | Storey: 2 | Edge= 3.11m SSL | NN=3.05 m | Shaft | 00.27 | 90.000000 | 2413 | Top= 0.17m FCL | Circulation | X=29.36 | Circulation
3.2.3 | 00 Ground floor | 2413.1 Pa | 3.25 m | 0.32 m/s | CC= 0.25m FCL | 03 | NNUK=3.04 m | CC= 3.25m FFB | Pipe insulation | ins= 9.000000 mm | CC= 3.25m SSL | ZP150/915 | .003 | Y=11.33 |  | Dra.no: 1 | 4 | .0002 | 0.04 l/s | 151.334382 l/h | 0.2 m\X\B3/h | Storey: 2 | Edge= 3.24m SSL | NN=3.05 m | Entrance | 00.01 | 0.000000 | 2413 | Top= 0.24m FCL | Circulation | X=21.81 | Circulation
3.2.4 | 00 Ground floor | 2413.1 Pa | 3.25 m | 0.32 m/s | CC= 0.05m FCL | 03 | NNUK=3.04 m | CC= 3.25m FFB | Pipe insulation | ins= 9.000000 mm | CC= 3.25m SSL | ZP150/915 | .004 | Y=15.07 |  | Dra.no: 1 | 4 | .0002 | 0.04 l/s | 151.334382 l/h | 0.2 m\X\B3/h | Storey: 2 | Edge= 3.24m SSL | NN=3.05 m | corridor | 00.04 | 0.000000 | 2413 | Top= 0.04m FCL | Circulation | X=21.81 | Circulation
3.6.2 | 00 Ground floor | 0.0 Pa | 3.00 m | 0.00 m/s | CC= 0.18m FCL | 03 | NNUK=2.79 m | CC= 3.12m FFB |  | ins= 0.000000 mm | CC= 3.12m SSL |  | .002 | Y=16.78 | Cooling | Dra.no: 1 | 189 | .0006 | 0.00 l/s | 0.000000 l/h | 0.0 m\X\B3/h | Storey: 2 | Edge= 3.11m SSL | NN=2.80 m | Office | 00.23 | 0.000000 | 0 | Top= 0.17m FCL | Cooling return | X=38.61 | Cooling return
3.6.3 | 00 Ground floor | 0.0 Pa | 3.00 m | 0.00 m/s | CC= 0.18m FCL | 03 | NNUK=2.79 m | CC= 3.12m FFB |  | ins= 0.000000 mm | CC= 3.12m SSL |  | .003 | Y=16.57 | Cooling | Dra.no: 1 | 189 | .0006 | 0.00 l/s | 0.000000 l/h | 0.0 m\X\B3/h | Storey: 2 | Edge= 3.11m SSL | NN=2.80 m | Office | 00.23 | 90.000000 | 0 | Top= 0.17m FCL | Cooling return | X=38.61 | Cooling return
3.7.2 | 00 Ground floor | 0.0 Pa | 3.00 m | 0.00 m/s | CC= 0.18m FCL | 03 | NNUK=2.79 m | CC= 3.12m FFB | Pipe insulation | ins= 9.000000 mm | CC= 3.12m SSL | ZP150/915 | .002 | Y=16.57 | Cooling | Dra.no: 1 | 189 | .0007 | 0.00 l/s | 0.000000 l/h | 0.0 m\X\B3/h | Storey: 2 | Edge= 3.11m SSL | NN=2.80 m | Office | 00.23 | 180.000000 | 0 | Top= 0.17m FCL | Cooling return | X=35.49 | Cooling return
1.16.1 | 01 First floor | 171184.2 Pa | 2.80 m | 0.53 m/s | CC= 0.63m FCL | 01 | NNUK=6.09 m | CC= 2.67m FFB | Pipe insulation | ins= 9.000000 mm | CC= 2.67m SSL | ZP150/915 | .001 | Y=15.05 | PW | Dra.no: 2 | 2 | .0016 | 0.07 l/s | 252.000001 l/h | 0.3 m\X\B3/h | Storey: 3 | Edge= 2.66m SSL | NN=6.10 m | corridor | 01.04 | 0.000000 | 171184 | Top= 0.62m FCL | Coldwater | X=22.16 | Coldwater
1.16.2 | 01 First floor | 171184.2 Pa | 2.80 m | 0.53 m/s | CC= 0.63m FCL | 01 | NNUK=6.09 m | CC= 2.67m FFB | Pipe insulation | ins= 9.000000 mm | CC= 2.67m SSL | ZP150/915 | .002 | Y=15.05 | PW | Dra.no: 2 | 2 | .0016 | 0.07 l/s | 252.000001 l/h | 0.3 m\X\B3/h | Storey: 3 | Edge= 2.66m SSL | NN=6.10 m | wc | 01.11 | 180.000000 | 171184 | Top= 0.62m FCL | Coldwater | X=23.31 | Coldwater
1.16.3 | 01 First floor | 171184.2 Pa | 2.80 m | 0.53 m/s | CC= 0.63m FCL | 01 | NNUK=6.09 m | CC= 2.67m FFB | Pipe insulation | ins= 9.000000 mm | CC= 2.67m SSL | ZP150/915 | .003 | Y=15.18 | PW | Dra.no: 2 | 2 | .0016 | 0.07 l/s | 252.000001 l/h | 0.3 m\X\B3/h | Storey: 3 | Edge= 2.66m SSL | NN=6.10 m | wc | 01.11 | 90.000000 | 171184 | Top= 0.62m FCL | Coldwater | X=23.31 | Coldwater
1.16.4 | 01 First floor | 171184.2 Pa | 0.63 m | 0.53 m/s | CC= 2.80m FCL | 01 | NNUK=3.92 m | CC= 0.50m FFB | Pipe insulation | ins= 9.000000 mm | CC= 0.50m SSL | ZP150/915 | .004 | Y=15.18 | PW | Dra.no: 2 | 2 | .0016 | 0.07 l/s | 252.000001 l/h | 0.3 m\X\B3/h | Storey: 3 | Edge= 0.49m SSL | NN=3.93 m | wc | 01.11 | 90.000000 | 171184 | Top= 2.79m FCL | Coldwater | X=23.31 | Coldwater
1.17.2 | 01 First floor | 170007.6 Pa | 0.63 m | 0.53 m/s | CC= 2.80m FCL | 01 | NNUK=3.92 m | CC= 0.50m FFB | Pipe insulation | ins= 9.000000 mm | CC= 0.50m SSL | ZP150/915 | .002 | Y=14.54 | PW | Dra.no: 2 | 2 | .0017 | 0.07 l/s | 252.000001 l/h | 0.3 m\X\B3/h | Storey: 3 | Edge= 0.49m SSL | NN=3.93 m | corridor | 01.04 | 270.000000 | 170008 | Top= 2.79m FCL | Coldwater | X=22.16 | Coldwater
1.18.2 | 01 First floor | 117559.8 Pa | 0.76 m | 0.98 m/s | CC= 2.55m FCL | 01 | NNUK=4.04 m | CC= 0.76m FFB | Pipe insulation | ins= 9.000000 mm | CC= 0.76m SSL | ZP150/915 | .002 | Y=13.86 | PW | Dra.no: 2 | 2 | .0018 | 0.13 l/s | 467.999983 l/h | 0.5 m\X\B3/h | Storey: 3 | Edge= 0.75m SSL | NN=4.06 m |  |  | 0.000000 | 117560 | Top= 0.00m FCL | Coldwater | X=22.28 | Coldwater
1.18.3 | 01 First floor | 117559.8 Pa | 0.76 m | 0.98 m/s | CC= 2.55m FCL | 01 | NNUK=4.04 m | CC= 0.76m FFB | Pipe insulation | ins= 9.000000 mm | CC= 0.76m SSL | ZP150/915 | .003 | Y=13.86 | PW | Dra.no: 2 | 2 | .0018 | 0.13 l/s | 467.999983 l/h | 0.5 m\X\B3/h | Storey: 3 | Edge= 0.75m SSL | NN=4.06 m |  |  | 270.000000 | 117560 | Top= 0.00m FCL | Coldwater | X=22.21 | Coldwater
1.18.4 | 01 First floor | 117559.8 Pa | 2.80 m | 0.98 m/s | CC= 0.50m FCL | 01 | NNUK=6.09 m | CC= 2.80m FFB | Pipe insulation | ins= 9.000000 mm | CC= 2.80m SSL | ZP150/915 | .004 | Y=13.86 | PW | Dra.no: 2 | 2 | .0018 | 0.13 l/s | 467.999983 l/h | 0.5 m\X\B3/h | Storey: 3 | Edge= 2.79m SSL | NN=6.10 m |  |  | 90.000000 | 117560 | Top= 0.00m FCL | Coldwater | X=22.21 | Coldwater
1.19.2 | 01 First floor | 170007.6 Pa | 0.63 m | 0.53 m/s | CC= 2.80m FCL | 01 | NNUK=3.92 m | CC= 0.50m FFB | Pipe insulation | ins= 9.000000 mm | CC= 0.50m SSL | ZP150/915 | .002 | Y=13.50 | PW | Dra.no: 2 | 2 | .0019 | 0.07 l/s | 252.000001 l/h | 0.3 m\X\B3/h | Storey: 3 | Edge= 0.49m SSL | NN=3.93 m | corridor | 01.04 | 270.000000 | 170008 | Top= 2.79m FCL | Coldwater | X=22.16 | Coldwater
1.20.2 | 01 First floor | 117584.3 Pa | 0.76 m | 0.98 m/s | CC= 2.55m FCL | 01 | NNUK=4.04 m | CC= 0.76m FFB | Pipe insulation | ins= 9.000000 mm | CC= 0.76m SSL | ZP150/915 | .002 | Y=12.73 | PW | Dra.no: 2 | 2 | .0020 | 0.13 l/s | 467.999983 l/h | 0.5 m\X\B3/h | Storey: 3 | Edge= 0.75m SSL | NN=4.06 m |  |  | 0.000000 | 117584 | Top= 0.00m FCL | Coldwater | X=22.28 | Coldwater
1.20.3 | 01 First floor | 117584.3 Pa | 0.76 m | 0.98 m/s | CC= 2.55m FCL | 01 | NNUK=4.04 m | CC= 0.76m FFB | Pipe insulation | ins= 9.000000 mm | CC= 0.76m SSL | ZP150/915 | .003 | Y=12.73 | PW | Dra.no: 2 | 2 | .0020 | 0.13 l/s | 467.999983 l/h | 0.5 m\X\B3/h | Storey: 3 | Edge= 0.75m SSL | NN=4.06 m |  |  | 270.000000 | 117584 | Top= 0.00m FCL | Coldwater | X=22.22 | Coldwater
1.20.4 | 01 First floor | 117584.3 Pa | 2.80 m | 0.98 m/s | CC= 0.50m FCL | 01 | NNUK=6.09 m | CC= 2.80m FFB | Pipe insulation | ins= 9.000000 mm | CC= 2.80m SSL | ZP150/915 | .004 | Y=12.73 | PW | Dra.no: 2 | 2 | .0020 | 0.13 l/s | 467.999983 l/h | 0.5 m\X\B3/h | Storey: 3 | Edge= 2.79m SSL | NN=6.10 m |  |  | 90.000000 | 117584 | Top= 0.00m FCL | Coldwater | X=22.22 | Coldwater
1.21.2 | 01 First floor | 170007.6 Pa | 0.63 m | 0.53 m/s | CC= 2.80m FCL | 01 | NNUK=3.92 m | CC= 0.50m FFB | Pipe insulation | ins= 9.000000 mm | CC= 0.50m SSL | ZP150/915 | .002 | Y=12.46 | PW | Dra.no: 2 | 2 | .0021 | 0.07 l/s | 252.000001 l/h | 0.3 m\X\B3/h | Storey: 3 | Edge= 0.49m SSL | NN=3.93 m | corridor | 01.04 | 270.000000 | 170008 | Top= 2.79m FCL | Coldwater | X=22.16 | Coldwater
1.22.2 | 01 First floor | 170651.6 Pa | 2.80 m | 0.53 m/s | CC= 0.63m FCL | 01 | NNUK=6.09 m | CC= 2.67m FFB | Pipe insulation | ins= 9.000000 mm | CC= 2.67m SSL | ZP150/915 | .002 | Y=12.00 | PW | Dra.no: 2 | 2 | .0022 | 0.07 l/s | 252.000001 l/h | 0.3 m\X\B3/h | Storey: 3 | Edge= 2.66m SSL | NN=6.10 m | Restaurant | 01.03 | 90.000000 | 170652 | Top= 0.62m FCL | Coldwater | X=23.11 | Coldwater
1.22.3 | 01 First floor | 170651.6 Pa | 0.63 m | 0.53 m/s | CC= 2.80m FCL | 01 | NNUK=3.92 m | CC= 0.50m FFB | Pipe insulation | ins= 9.000000 mm | CC= 0.50m SSL | ZP150/915 | .003 | Y=12.00 | PW | Dra.no: 2 | 2 | .0022 | 0.07 l/s | 252.000001 l/h | 0.3 m\X\B3/h | Storey: 3 | Edge= 0.49m SSL | NN=3.93 m | Restaurant | 01.03 | 270.000000 | 170652 | Top= 2.79m FCL | Coldwater | X=23.11 | Coldwater
1.6.1 | 01 First floor | 136144.2 Pa | 2.80 m | 1.55 m/s | CC= 0.63m FCL | 01 | NNUK=6.09 m | CC= 2.67m FFB | Pipe insulation | ins= 9.000000 mm | CC= 2.67m SSL | ZP150/915 | .001 | Y=10.94 | PW | Dra.no: 2 | 2 | .0006 | 0.26 l/s | 935.999966 l/h | 0.9 m\X\B3/h | Storey: 3 | Edge= 2.66m SSL | NN=6.10 m | Restaurant | 01.03 | 0.000000 | 13548 | Top= 0.62m FCL | Coldwater | X=18.95 | Coldwater
1.8.1 | 01 First floor | 119003.3 Pa | 2.80 m | 0.98 m/s | CC= 0.63m FCL | 01 | NNUK=6.09 m | CC= 2.67m FFB | Pipe insulation | ins= 9.000000 mm | CC= 2.67m SSL | ZP150/915 | .001 | Y=14.36 | PW | Dra.no: 2 | 2 | .0008 | 0.13 l/s | 467.999983 l/h | 0.5 m\X\B3/h | Storey: 3 | Edge= 2.66m SSL | NN=6.10 m | wc | 01.08 | 180.000000 | 119003 | Top= 0.62m FCL | Coldwater | X=18.95 | Coldwater
1.8.2 | 01 First floor | 119003.3 Pa | 0.76 m | 0.98 m/s | CC= 2.55m FCL | 01 | NNUK=4.04 m | CC= 0.76m FFB | Pipe insulation | ins= 9.000000 mm | CC= 0.76m SSL | ZP150/915 | .002 | Y=14.36 | PW | Dra.no: 2 | 2 | .0008 | 0.13 l/s | 467.999983 l/h | 0.5 m\X\B3/h | Storey: 3 | Edge= 0.75m SSL | NN=4.06 m |  |  | 180.000000 | 119003 | Top= 0.00m FCL | Coldwater | X=18.73 | Coldwater
1.8.3 | 01 First floor | 119003.3 Pa | 0.76 m | 0.98 m/s | CC= 2.68m FCL | 01 | NNUK=4.04 m | CC= 0.62m FFB | Pipe insulation | ins= 9.000000 mm | CC= 0.62m SSL | ZP150/915 | .003 | Y=14.36 | PW | Dra.no: 2 | 2 | .0008 | 0.13 l/s | 467.999983 l/h | 0.5 m\X\B3/h | Storey: 3 | Edge= 0.62m SSL | NN=4.06 m | wc | 01.08 | 270.000000 | 119003 | Top= 2.67m FCL | Coldwater | X=18.78 | Coldwater
1.8.4 | 01 First floor | 119003.3 Pa | 2.80 m | 0.98 m/s | CC= 0.63m FCL | 01 | NNUK=6.09 m | CC= 2.67m FFB | Pipe insulation | ins= 9.000000 mm | CC= 2.67m SSL | ZP150/915 | .004 | Y=14.36 | PW | Dra.no: 2 | 2 | .0008 | 0.13 l/s | 467.999983 l/h | 0.5 m\X\B3/h | Storey: 3 | Edge= 2.66m SSL | NN=6.10 m | wc | 01.08 | 90.000000 | 119003 | Top= 0.62m FCL | Coldwater | X=18.78 | Coldwater
1.9.2 | 01 First floor | 117642.0 Pa | 0.76 m | 0.98 m/s | CC= 2.55m FCL | 01 | NNUK=4.04 m | CC= 0.76m FFB | Pipe insulation | ins= 9.000000 mm | CC= 0.76m SSL | ZP150/915 | .002 | Y=13.31 | PW | Dra.no: 2 | 2 | .0009 | 0.13 l/s | 467.999983 l/h | 0.5 m\X\B3/h | Storey: 3 | Edge= 0.75m SSL | NN=4.06 m |  |  | 180.000000 | 117642 | Top= 0.00m FCL | Coldwater | X=18.73 | Coldwater
1.9.3 | 01 First floor | 117642.0 Pa | 0.76 m | 0.98 m/s | CC= 2.68m FCL | 01 | NNUK=4.04 m | CC= 0.62m FFB | Pipe insulation | ins= 9.000000 mm | CC= 0.62m SSL | ZP150/915 | .003 | Y=13.31 | PW | Dra.no: 2 | 2 | .0009 | 0.13 l/s | 467.999983 l/h | 0.5 m\X\B3/h | Storey: 3 | Edge= 0.62m SSL | NN=4.06 m | wc | 01.09 | 270.000000 | 117642 | Top= 2.67m FCL | Coldwater | X=18.78 | Coldwater
1.9.4 | 01 First floor | 117642.0 Pa | 2.80 m | 0.98 m/s | CC= 0.63m FCL | 01 | NNUK=6.09 m | CC= 2.67m FFB | Pipe insulation | ins= 9.000000 mm | CC= 2.67m SSL | ZP150/915 | .004 | Y=13.31 | PW | Dra.no: 2 | 2 | .0009 | 0.13 l/s | 467.999983 l/h | 0.5 m\X\B3/h | Storey: 3 | Edge= 2.66m SSL | NN=6.10 m | wc | 01.09 | 90.000000 | 117642 | Top= 0.62m FCL | Coldwater | X=18.78 | Coldwater
2.13.1 | 01 First floor | 181991.0 Pa | 2.88 m | 1.67 m/s | CC= 0.56m FCL | 02 | NNUK=6.16 m | CC= 2.75m FFB | Pipe insulation | ins= 9.000000 mm | CC= 2.75m SSL | ZP150/915 | .001 | Y=11.09 |  | Dra.no: 2 | 3 | .0013 | 0.28 l/s | 1008.000004 l/h | 1.0 m\X\B3/h | Storey: 3 | Edge= 2.74m SSL | NN=6.18 m | Restaurant | 01.03 | 0.000000 | 9246 | Top= 0.55m FCL | Hotwater | X=22.04 | Hotwater
2.16.1 | 01 First floor | 169480.5 Pa | 2.88 m | 0.53 m/s | CC= 0.56m FCL | 02 | NNUK=6.16 m | CC= 2.75m FFB | Pipe insulation | ins= 9.000000 mm | CC= 2.75m SSL | ZP150/915 | .001 | Y=15.01 |  | Dra.no: 2 | 3 | .0016 | 0.07 l/s | 252.000001 l/h | 0.3 m\X\B3/h | Storey: 3 | Edge= 2.74m SSL | NN=6.18 m | corridor | 01.04 | 0.000000 | 949 | Top= 0.55m FCL | Hotwater | X=22.04 | Hotwater
2.16.2 | 01 First floor | 169480.5 Pa | 2.88 m | 0.53 m/s | CC= 0.56m FCL | 02 | NNUK=6.16 m | CC= 2.75m FFB | Pipe insulation | ins= 9.000000 mm | CC= 2.75m SSL | ZP150/915 | .002 | Y=15.01 |  | Dra.no: 2 | 3 | .0016 | 0.07 l/s | 252.000001 l/h | 0.3 m\X\B3/h | Storey: 3 | Edge= 2.74m SSL | NN=6.18 m | wc | 01.11 | 180.000000 | 949 | Top= 0.55m FCL | Hotwater | X=23.11 | Hotwater
2.17.1 | 01 First floor | 168531.1 Pa | 2.88 m | 0.53 m/s | CC= 0.56m FCL | 02 | NNUK=6.16 m | CC= 2.75m FFB | Pipe insulation | ins= 9.000000 mm | CC= 2.75m SSL | ZP150/915 | .001 | Y=15.18 |  | Dra.no: 2 | 3 | .0017 | 0.07 l/s | 252.000001 l/h | 0.3 m\X\B3/h | Storey: 3 | Edge= 2.74m SSL | NN=6.18 m | wc | 01.11 | 90.000000 | 168531 | Top= 0.55m FCL | Hotwater | X=23.11 | Hotwater
2.17.2 | 01 First floor | 168531.1 Pa | 0.63 m | 0.53 m/s | CC= 2.80m FCL | 02 | NNUK=3.92 m | CC= 0.50m FFB | Pipe insulation | ins= 9.000000 mm | CC= 0.50m SSL | ZP150/915 | .002 | Y=15.18 |  | Dra.no: 2 | 3 | .0017 | 0.07 l/s | 252.000001 l/h | 0.3 m\X\B3/h | Storey: 3 | Edge= 0.49m SSL | NN=3.93 m | wc | 01.11 | 90.000000 | 168531 | Top= 2.79m FCL | Hotwater | X=23.11 | Hotwater
2.18.2 | 01 First floor | 168977.1 Pa | 2.92 m | 0.53 m/s | CC= 0.51m FCL | 02 | NNUK=6.21 m | CC= 2.79m FFB | Pipe insulation | ins= 9.000000 mm | CC= 2.79m SSL | ZP150/915 | .002 | Y=14.74 |  | Dra.no: 2 | 3 | .0018 | 0.07 l/s | 252.000001 l/h | 0.3 m\X\B3/h | Storey: 3 | Edge= 2.79m SSL | NN=6.22 m | corridor | 01.04 | 90.000000 | 168977 | Top= 0.50m FCL | Hotwater | X=22.04 | Hotwater
2.18.3 | 01 First floor | 168977.1 Pa | 2.92 m | 0.53 m/s | CC= 0.38m FCL | 02 | NNUK=6.21 m | CC= 2.92m FFB | Pipe insulation | ins= 9.000000 mm | CC= 2.92m SSL | ZP150/915 | .003 | Y=14.74 |  | Dra.no: 2 | 3 | .0018 | 0.07 l/s | 252.000001 l/h | 0.3 m\X\B3/h | Storey: 3 | Edge= 2.92m SSL | NN=6.22 m |  |  | 90.000000 | 168977 | Top= 0.00m FCL | Hotwater | X=22.21 | Hotwater
2.18.4 | 01 First floor | 168977.1 Pa | 0.63 m | 0.53 m/s | CC= 2.67m FCL | 02 | NNUK=3.92 m | CC= 0.63m FFB | Pipe insulation | ins= 9.000000 mm | CC= 0.63m SSL | ZP150/915 | .004 | Y=14.74 |  | Dra.no: 2 | 3 | .0018 | 0.07 l/s | 252.000001 l/h | 0.3 m\X\B3/h | Storey: 3 | Edge= 0.62m SSL | NN=3.93 m |  |  | 90.000000 | 168977 | Top= 0.00m FCL | Hotwater | X=22.21 | Hotwater
2.19.2 | 01 First floor | 168975.5 Pa | 2.92 m | 0.53 m/s | CC= 0.51m FCL | 02 | NNUK=6.21 m | CC= 2.79m FFB | Pipe insulation | ins= 9.000000 mm | CC= 2.79m SSL | ZP150/915 | .002 | Y=13.70 |  | Dra.no: 2 | 3 | .0019 | 0.07 l/s | 252.000001 l/h | 0.3 m\X\B3/h | Storey: 3 | Edge= 2.79m SSL | NN=6.22 m | corridor | 01.04 | 90.000000 | 168976 | Top= 0.50m FCL | Hotwater | X=22.04 | Hotwater
2.19.3 | 01 First floor | 168975.5 Pa | 2.92 m | 0.53 m/s | CC= 0.38m FCL | 02 | NNUK=6.21 m | CC= 2.92m FFB | Pipe insulation | ins= 9.000000 mm | CC= 2.92m SSL | ZP150/915 | .003 | Y=13.70 |  | Dra.no: 2 | 3 | .0019 | 0.07 l/s | 252.000001 l/h | 0.3 m\X\B3/h | Storey: 3 | Edge= 2.92m SSL | NN=6.22 m |  |  | 90.000000 | 168976 | Top= 0.00m FCL | Hotwater | X=22.22 | Hotwater
2.19.4 | 01 First floor | 168975.5 Pa | 0.63 m | 0.53 m/s | CC= 2.67m FCL | 02 | NNUK=3.92 m | CC= 0.63m FFB | Pipe insulation | ins= 9.000000 mm | CC= 0.63m SSL | ZP150/915 | .004 | Y=13.70 |  | Dra.no: 2 | 3 | .0019 | 0.07 l/s | 252.000001 l/h | 0.3 m\X\B3/h | Storey: 3 | Edge= 0.62m SSL | NN=3.93 m |  |  | 90.000000 | 168976 | Top= 0.00m FCL | Hotwater | X=22.22 | Hotwater
2.20.2 | 01 First floor | 168976.0 Pa | 2.92 m | 0.53 m/s | CC= 0.51m FCL | 02 | NNUK=6.21 m | CC= 2.79m FFB | Pipe insulation | ins= 9.000000 mm | CC= 2.79m SSL | ZP150/915 | .002 | Y=12.66 |  | Dra.no: 2 | 3 | .0020 | 0.07 l/s | 252.000001 l/h | 0.3 m\X\B3/h | Storey: 3 | Edge= 2.79m SSL | NN=6.22 m | corridor | 01.04 | 90.000000 | 168976 | Top= 0.50m FCL | Hotwater | X=22.04 | Hotwater
2.20.3 | 01 First floor | 168976.0 Pa | 2.92 m | 0.53 m/s | CC= 0.38m FCL | 02 | NNUK=6.21 m | CC= 2.92m FFB | Pipe insulation | ins= 9.000000 mm | CC= 2.92m SSL | ZP150/915 | .003 | Y=12.66 |  | Dra.no: 2 | 3 | .0020 | 0.07 l/s | 252.000001 l/h | 0.3 m\X\B3/h | Storey: 3 | Edge= 2.92m SSL | NN=6.22 m |  |  | 90.000000 | 168976 | Top= 0.00m FCL | Hotwater | X=22.20 | Hotwater
2.20.4 | 01 First floor | 168976.0 Pa | 0.63 m | 0.53 m/s | CC= 2.67m FCL | 02 | NNUK=3.92 m | CC= 0.63m FFB | Pipe insulation | ins= 9.000000 mm | CC= 0.63m SSL | ZP150/915 | .004 | Y=12.66 |  | Dra.no: 2 | 3 | .0020 | 0.07 l/s | 252.000001 l/h | 0.3 m\X\B3/h | Storey: 3 | Edge= 0.62m SSL | NN=3.93 m |  |  | 90.000000 | 168976 | Top= 0.00m FCL | Hotwater | X=22.20 | Hotwater
2.21.2 | 01 First floor | 168937.4 Pa | 2.88 m | 0.53 m/s | CC= 0.56m FCL | 02 | NNUK=6.16 m | CC= 2.75m FFB | Pipe insulation | ins= 9.000000 mm | CC= 2.75m SSL | ZP150/915 | .002 | Y=12.01 |  | Dra.no: 2 | 3 | .0021 | 0.07 l/s | 252.000001 l/h | 0.3 m\X\B3/h | Storey: 3 | Edge= 2.74m SSL | NN=6.18 m | wc | 01.10 | 90.000000 | 168937 | Top= 0.55m FCL | Hotwater | X=23.31 | Hotwater
2.21.3 | 01 First floor | 168937.4 Pa | 0.63 m | 0.53 m/s | CC= 2.80m FCL | 02 | NNUK=3.92 m | CC= 0.50m FFB | Pipe insulation | ins= 9.000000 mm | CC= 0.50m SSL | ZP150/915 | .003 | Y=12.01 |  | Dra.no: 2 | 3 | .0021 | 0.07 l/s | 252.000001 l/h | 0.3 m\X\B3/h | Storey: 3 | Edge= 0.49m SSL | NN=3.93 m | wc | 01.10 | 270.000000 | 168937 | Top= 2.79m FCL | Hotwater | X=23.31 | Hotwater
3.3.2 | 01 First floor | 1390.9 Pa | 2.95 m | 0.28 m/s | CC= 0.48m FCL | 03 | NNUK=6.24 m | CC= 2.82m FFB | Pipe insulation | ins= 9.000000 mm | CC= 2.82m SSL | ZP150/915 | .002 | Y=11.33 |  | Dra.no: 2 | 4 | .0003 | 0.04 l/s | 131.573703 l/h | 0.1 m\X\B3/h | Storey: 3 | Edge= 2.81m SSL | NN=6.25 m | Restaurant | 01.03 | 0.000000 | 1391 | Top= 0.47m FCL | Circulation | X=21.83 | Circulation
3.3.3 | 01 First floor | 1390.9 Pa | 2.95 m | 0.28 m/s | CC= 0.48m FCL | 03 | NNUK=6.24 m | CC= 2.82m FFB | Pipe insulation | ins= 9.000000 mm | CC= 2.82m SSL | ZP150/915 | .003 | Y=15.11 |  | Dra.no: 2 | 4 | .0003 | 0.04 l/s | 131.573703 l/h | 0.1 m\X\B3/h | Storey: 3 | Edge= 2.81m SSL | NN=6.25 m | corridor | 01.04 | 0.000000 | 1391 | Top= 0.47m FCL | Circulation | X=21.83 | Circulation
3.3.4 | 01 First floor | 1390.9 Pa | 2.95 m | 0.28 m/s | CC= 0.48m FCL | 03 | NNUK=6.24 m | CC= 2.82m FFB | Pipe insulation | ins= 9.000000 mm | CC= 2.82m SSL | ZP150/915 | .004 | Y=15.11 |  | Dra.no: 2 | 4 | .0003 | 0.04 l/s | 131.573703 l/h | 0.1 m\X\B3/h | Storey: 3 | Edge= 2.81m SSL | NN=6.25 m | wc | 01.11 | 90.000000 | 1391 | Top= 0.47m FCL | Circulation | X=23.11 | Circulation
Bend | 00 Ground floor | 0.0 Pa | 3.10 m | 0.00 m/s | CC= 0.20m FCL | 00 | NNUK=2.89 m | CC= 3.10m FFB | Pipe insulation | ins= 9.000000 mm | CC= 3.10m SSL | ZP150/915 | .000 | Y=12.46 |  | Dra.no: 1 | 2 | .0001 | 0.00 l/s | 0.000000 l/h | 0.0 m\X\B3/h | Storey: 2 | Edge= 3.09m SSL | NN=2.90 m | corridor | 00.04 | 90.000000 | 0 | Top= 0.19m FCL | Coldwater | X=22.17
Bend | 00 Ground floor | 0.0 Pa | 0.63 m | 0.00 m/s | CC= 2.67m FCL | 00 | NNUK=0.42 m | CC= 0.63m FFB | Pipe insulation | ins= 9.000000 mm | CC= 0.63m SSL | ZP150/915 | .000 | Y=13.70 |  | Dra.no: 1 | 3 | .0001 | 0.00 l/s | 0.000000 l/h | 0.0 m\X\B3/h | Storey: 2 | Edge= 0.62m SSL | NN=0.43 m | corridor | 00.04 | 90.000000 | 0 | Top= 2.66m FCL | Hotwater | X=22.17
Bend | 00 Ground floor | 0.0 Pa | 3.22 m | 0.00 m/s | CC= 0.08m FCL | 00 | NNUK=3.01 m | CC= 3.22m FFB | Pipe insulation | ins= 9.000000 mm | CC= 3.22m SSL | ZP150/915 | .000 | Y=13.70 |  | Dra.no: 1 | 3 | .0001 | 0.00 l/s | 0.000000 l/h | 0.0 m\X\B3/h | Storey: 2 | Edge= 3.21m SSL | NN=3.02 m | corridor | 00.04 | 90.000000 | 0 | Top= 0.08m FCL | Hotwater | X=22.17
Bend | 00 Ground floor | 0.0 Pa | 3.22 m | 0.00 m/s | CC= 0.08m FCL | 00 | NNUK=3.01 m | CC= 3.22m FFB | Pipe insulation | ins= 9.000000 mm | CC= 3.22m SSL | ZP150/915 | .000 | Y=13.70 |  | Dra.no: 1 | 3 | .0001 | 0.00 l/s | 0.000000 l/h | 0.0 m\X\B3/h | Storey: 2 | Edge= 3.21m SSL | NN=3.02 m | corridor | 00.04 | 90.000000 | 0 | Top= 0.08m FCL | Hotwater | X=21.91
Bend | 00 Ground floor | 0.0 Pa | 0.63 m | 0.00 m/s | CC= 2.67m FCL | 00 | NNUK=0.42 m | CC= 0.63m FFB | Pipe insulation | ins= 9.000000 mm | CC= 0.63m SSL | ZP150/915 | .000 | Y=13.50 |  | Dra.no: 1 | 2 | .0001 | 0.00 l/s | 0.000000 l/h | 0.0 m\X\B3/h | Storey: 2 | Edge= 0.62m SSL | NN=0.43 m | corridor | 00.04 | 90.000000 | 0 | Top= 2.66m FCL | Coldwater | X=22.17
Bend | 00 Ground floor | 0.0 Pa | 3.10 m | 0.00 m/s | CC= 0.20m FCL | 00 | NNUK=2.89 m | CC= 3.10m FFB | Pipe insulation | ins= 9.000000 mm | CC= 3.10m SSL | ZP150/915 | .000 | Y=13.50 |  | Dra.no: 1 | 2 | .0001 | 0.00 l/s | 0.000000 l/h | 0.0 m\X\B3/h | Storey: 2 | Edge= 3.09m SSL | NN=2.90 m | corridor | 00.04 | 90.000000 | 0 | Top= 0.19m FCL | Coldwater | X=22.17
Bend | 00 Ground floor | 0.0 Pa | 0.63 m | 0.00 m/s | CC= 2.67m FCL | 00 | NNUK=0.42 m | CC= 0.63m FFB | Pipe insulation | ins= 9.000000 mm | CC= 0.63m SSL | ZP150/915 | .000 | Y=14.74 |  | Dra.no: 1 | 3 | .0001 | 0.00 l/s | 0.000000 l/h | 0.0 m\X\B3/h | Storey: 2 | Edge= 0.62m SSL | NN=0.43 m | corridor | 00.04 | 90.000000 | 0 | Top= 2.66m FCL | Hotwater | X=22.16
Bend | 00 Ground floor | 0.0 Pa | 3.22 m | 0.00 m/s | CC= 0.08m FCL | 00 | NNUK=3.01 m | CC= 3.22m FFB | Pipe insulation | ins= 9.000000 mm | CC= 3.22m SSL | ZP150/915 | .000 | Y=14.74 |  | Dra.no: 1 | 3 | .0001 | 0.00 l/s | 0.000000 l/h | 0.0 m\X\B3/h | Storey: 2 | Edge= 3.21m SSL | NN=3.02 m | corridor | 00.04 | 90.000000 | 0 | Top= 0.08m FCL | Hotwater | X=22.16
Bend | 00 Ground floor | 0.0 Pa | 3.22 m | 0.00 m/s | CC= 0.08m FCL | 00 | NNUK=3.01 m | CC= 3.22m FFB | Pipe insulation | ins= 9.000000 mm | CC= 3.22m SSL | ZP150/915 | .000 | Y=14.74 |  | Dra.no: 1 | 3 | .0001 | 0.00 l/s | 0.000000 l/h | 0.0 m\X\B3/h | Storey: 2 | Edge= 3.21m SSL | NN=3.02 m | corridor | 00.04 | 90.000000 | 0 | Top= 0.08m FCL | Hotwater | X=21.91
Bend | 00 Ground floor | 0.0 Pa | 2.90 m | 0.00 m/s | CC= 0.28m FCL | 00 | NNUK=2.69 m | CC= 3.02m FFB | Pipe insulation | ins= 9.000000 mm | CC= 3.02m SSL | ZP150/915 | .000 | Y=20.32 |  | Dra.no: 1 | 188 | .0001 | 0.00 l/s | 0.000000 l/h | 0.0 m\X\B3/h | Storey: 2 | Edge= 3.01m SSL | NN=2.70 m | Office | 00.23 | 180.000000 | 0 | Top= 0.27m FCL | Cooling Flow | X=35.55
Bend | 00 Ground floor | 0.0 Pa | 0.63 m | 0.00 m/s | CC= 2.67m FCL | 00 | NNUK=0.42 m | CC= 0.63m FFB | Pipe insulation | ins= 9.000000 mm | CC= 0.63m SSL | ZP150/915 | .000 | Y=14.54 |  | Dra.no: 1 | 2 | .0001 | 0.00 l/s | 0.000000 l/h | 0.0 m\X\B3/h | Storey: 2 | Edge= 0.62m SSL | NN=0.43 m | corridor | 00.04 | 90.000000 | 0 | Top= 2.66m FCL | Coldwater | X=22.17
Bend | 00 Ground floor | 0.0 Pa | 3.10 m | 0.00 m/s | CC= 0.20m FCL | 00 | NNUK=2.89 m | CC= 3.10m FFB | Pipe insulation | ins= 9.000000 mm | CC= 3.10m SSL | ZP150/915 | .000 | Y=14.54 |  | Dra.no: 1 | 2 | .0001 | 0.00 l/s | 0.000000 l/h | 0.0 m\X\B3/h | Storey: 2 | Edge= 3.09m SSL | NN=2.90 m | corridor | 00.04 | 90.000000 | 0 | Top= 0.19m FCL | Coldwater | X=22.17
Bend | 00 Ground floor | 0.0 Pa | 0.63 m | 0.00 m/s | CC= 2.67m FCL | 00 | NNUK=0.42 m | CC= 0.63m FFB | Pipe insulation | ins= 9.000000 mm | CC= 0.63m SSL | ZP150/915 | .000 | Y=12.66 |  | Dra.no: 1 | 3 | .0001 | 0.00 l/s | 0.000000 l/h | 0.0 m\X\B3/h | Storey: 2 | Edge= 0.62m SSL | NN=0.43 m | corridor | 00.04 | 90.000000 | 0 | Top= 2.66m FCL | Hotwater | X=22.16
Bend | 00 Ground floor | 0.0 Pa | 3.22 m | 0.00 m/s | CC= 0.08m FCL | 00 | NNUK=3.01 m | CC= 3.22m FFB | Pipe insulation | ins= 9.000000 mm | CC= 3.22m SSL | ZP150/915 | .000 | Y=12.66 |  | Dra.no: 1 | 3 | .0001 | 0.00 l/s | 0.000000 l/h | 0.0 m\X\B3/h | Storey: 2 | Edge= 3.21m SSL | NN=3.02 m | corridor | 00.04 | 90.000000 | 0 | Top= 0.08m FCL | Hotwater | X=22.16
Bend | 00 Ground floor | 0.0 Pa | 3.00 m | 0.00 m/s | CC= 0.18m FCL | 00 | NNUK=2.79 m | CC= 3.12m FFB | Pipe insulation | ins= 9.000000 mm | CC= 3.12m SSL | ZP150/915 | .000 | Y=20.32 |  | Dra.no: 1 | 189 | .0000 | 0.00 l/s | 0.000000 l/h | 0.0 m\X\B3/h | Storey: 2 | Edge= 3.11m SSL | NN=2.80 m | Office | 00.23 | 180.000000 | 0 | Top= 0.17m FCL | Cooling return | X=35.49
Bend | 00 Ground floor | 0.0 Pa | 3.22 m | 0.00 m/s | CC= 0.08m FCL | 00 | NNUK=3.01 m | CC= 3.22m FFB | Pipe insulation | ins= 9.000000 mm | CC= 3.22m SSL | ZP150/915 | .000 | Y=12.66 |  | Dra.no: 1 | 3 | .0001 | 0.00 l/s | 0.000000 l/h | 0.0 m\X\B3/h | Storey: 2 | Edge= 3.21m SSL | NN=3.02 m | corridor | 00.04 | 90.000000 | 0 | Top= 0.08m FCL | Hotwater | X=21.91
Bend | 00 Ground floor | 0.0 Pa | 0.63 m | 0.00 m/s | CC= 2.67m FCL | 00 | NNUK=0.42 m | CC= 0.63m FFB | Pipe insulation | ins= 9.000000 mm | CC= 0.63m SSL | ZP150/915 | .000 | Y=12.46 |  | Dra.no: 1 | 2 | .0001 | 0.00 l/s | 0.000000 l/h | 0.0 m\X\B3/h | Storey: 2 | Edge= 0.62m SSL | NN=0.43 m | corridor | 00.04 | 90.000000 | 0 | Top= 2.66m FCL | Coldwater | X=22.17
Bend | 01 First floor | 0.0 Pa | 2.80 m | 0.00 m/s | CC= 0.63m FCL | 00 | NNUK=6.09 m | CC= 2.67m FFB | Pipe insulation | ins= 9.000000 mm | CC= 2.67m SSL | ZP150/915 | .009 | Y=12.24 |  | Dra.no: 2 | 2 | .0000 | 0.00 l/s | 0.000000 l/h | 0.0 m\X\B3/h | Storey: 3 | Edge= 2.66m SSL | NN=6.10 m | wc | 01.07 | 90.000000 | 0 | Top= 0.62m FCL | Coldwater | X=18.78
Bend | 01 First floor | 0.0 Pa | 0.76 m | 0.00 m/s | CC= 2.68m FCL | 00 | NNUK=4.04 m | CC= 0.62m FFB | Pipe insulation | ins= 9.000000 mm | CC= 0.62m SSL | ZP150/915 | .008 | Y=12.24 |  | Dra.no: 2 | 2 | .0000 | 0.00 l/s | 0.000000 l/h | 0.0 m\X\B3/h | Storey: 3 | Edge= 0.62m SSL | NN=4.06 m | wc | 01.07 | 270.000000 | 0 | Top= 2.67m FCL | Coldwater | X=18.78
Bend | 01 First floor | 0.0 Pa | 0.76 m | 0.00 m/s | CC= 2.55m FCL | 00 | NNUK=4.04 m | CC= 0.76m FFB | Pipe insulation | ins= 9.000000 mm | CC= 0.76m SSL | ZP150/915 | .007 | Y=12.24 |  | Dra.no: 2 | 2 | .0000 | 0.00 l/s | 0.000000 l/h | 0.0 m\X\B3/h | Storey: 3 | Edge= 0.75m SSL | NN=4.06 m |  |  | 180.000000 | 0 | Top= 0.00m FCL | Coldwater | X=18.73

# IfcFlowFitting: BE3000018030 (4)
In: 02 Second floor
Type - Description: Cu fitting bend 30\X\B0 18x1 mm; ApplicableOccurrence: Basic; PredefinedType: BEND
Type - Pset_ManufacturerTypeInformation - ArticleNumber: BE3000018030; ModelReference: Cu fitting bend 30\X\B0 18x1 mm; Manufacturer: DDS
Type - Pset_PipeFittingTypeCommon - SubType: Bend 30 degree; NominalDiameter: 15; InnerDiameter: 16; OuterDiameter: 18
Material: IFC Building Material
Pset_DDS - Mounting Height: 2.80 m; Pipe thickness:: x1.0; Mtg. Below Ceiling ref Center: CC= 0.63m FCL; Product: Cu fitting bend 30\X\B0 18x1 mm; Insulation product text: Pipe insulation; Manufacturer: DDS; Ins thickness: ins= 9.000000 mm; Mtg. above Finished Floor ref Center: CC= 2.67m FFB; Insulation product number: ZP150/918; Outside dimension: 18.000000; Above Sea Level ref. Bottom: NNUK=9.59 m; Model Number: Dra.no: 3; Product Number: BE3000018030; Mtg. Below Ceiling ref Top: Top= 0.62m FCL; Mtg. Above Slab ref Bottom: Edge= 2.66m SSL; Project name: OpenBIM; Height: 0; Insulation k-value: 0; Insulation WSVO: 0; Room tekst: Unnamed; Mtg. Above Slab ref Center: CC= 2.67m SSL; Floor number: Storey: 4; Width: 15; Above Sea Level ref. Center: NN=9.60 m; Length: 30.0 m; Sub string number: .0001; Room number: 02.03; Dimension DN: 15 mm; Building Part: Building: 0
AC_Pset_RenovationAndPhasing - Renovation Status: Existing
Name | Flow (l/h) | Medium = Group | Rotation | Main string number | Y | Layer number | Flow (m\X\B3/h) | X | Part number | Pressure drop | Abs. pressure | Flow (l/s) | Velocity
2.1.10 | 2520.000011 l/h | Hotwater | 180.000000 | 02 | Y=11.00 | 3 | 2.5 m\X\B3/h | X=28.85 | .010 | 72106 | 276179.0 Pa | 0.70 l/s | 2.20 m/s
2.1.11 | 2520.000011 l/h | Hotwater | 0.000000 | 02 | Y=11.09 | 3 | 2.5 m\X\B3/h | X=29.00 | .011 | 72106 | 276179.0 Pa | 0.70 l/s | 2.20 m/s
3.1.15 | 282.908085 l/h | Circulation | 180.000000 | 03 | Y=11.10 | 4 | 0.3 m\X\B3/h | X=28.80 | .015 | 3343 | 5756.1 Pa | 0.08 l/s | 0.39 m/s
3.1.16 | 282.908085 l/h | Circulation | 0.000000 | 03 | Y=11.33 | 4 | 0.3 m\X\B3/h | X=29.18 | .016 | 3343 | 5756.1 Pa | 0.08 l/s | 0.39 m/s

# IfcFlowFitting: BE3000018090 (171)
Type - Description: Cu fitting bend 90\X\B0 18x1 mm; ApplicableOccurrence: Basic; PredefinedType: BEND
Type - Pset_ManufacturerTypeInformation - ArticleNumber: BE3000018090; ModelReference: Cu fitting bend 90\X\B0 18x1 mm; Manufacturer: DDS
Type - Pset_PipeFittingTypeCommon - SubType: Bend 90 degree; NominalDiameter: 15; InnerDiameter: 16; OuterDiameter: 18
Material: IFC Building Material
Pset_DDS - Pipe thickness:: x1.0; Product: Cu fitting bend 90\X\B0 18x1 mm; Manufacturer: DDS; Outside dimension: 18.000000; Product Number: BE3000018090; Project name: OpenBIM; Height: 0; Insulation k-value: 0; Insulation WSVO: 0; Width: 15; Length: 90.0 m; Dimension DN: 15 mm; Building Part: Building: 0
AC_Pset_RenovationAndPhasing - Renovation Status: Existing
Name | In | Mtg. Above Slab ref Center | Above Sea Level ref. Bottom | Mounting Height | Above Sea Level ref. Center | Main string number | Ins thickness | Room tekst | Mtg. Below Ceiling ref Top | Mtg. Above Slab ref Bottom | X | Y | Room number | Mtg. Below Ceiling ref Center | Model Number | Layer number | Pressure drop | Flow (m\X\B3/h) | Floor number | Flow (l/h) | Part number | Sub string number | Rotation | Medium | Mtg. above Finished Floor ref Center | Flow (l/s) | Abs. pressure | Velocity
2.2.0 | 00 Ground floor | CC= 3.02m SSL | NNUK=2.69 m | 2.90 m | NN=2.70 m | 02 | ins= 0.000000 mm | FB | Top= 0.27m FCL | Edge= 3.01m SSL | X=32.17 | Y=20.48 | 00.16 | CC= 0.28m FCL | Dra.no: 1 | 188 | 0 | 0.0 m\X\B3/h | Storey: 2 | 0.000000 l/h | .000 | .0002 | 0.000000 | Cooling Flow | CC= 3.02m FFB | 0.00 l/s | 0.0 Pa | 0.00 m/s | Pset_DDS - System Name: Cooling; Group: Cooling flow
2.2.0 | 00 Ground floor | CC= 2.90m SSL | NNUK=2.69 m | 2.90 m | NN=2.70 m | 02 | ins= 0.000000 mm | Hallway | Top= 0.39m FCL | Edge= 2.89m SSL | X=32.17 | Y=18.49 | 00.03 | CC= 0.40m FCL | Dra.no: 1 | 188 | 0 | 0.0 m\X\B3/h | Storey: 2 | 0.000000 l/h | .000 | .0002 | 90.000000 | Cooling Flow | CC= 2.90m FFB | 0.00 l/s | 0.0 Pa | 0.00 m/s | Pset_DDS - System Name: Cooling; Group: Cooling flow
2.2.0 | 00 Ground floor | CC= 2.80m SSL | NNUK=2.59 m | 2.80 m | NN=2.60 m | 02 | ins= 0.000000 mm | Hallway | Top= 0.49m FCL | Edge= 2.79m SSL | X=32.17 | Y=18.49 | 00.03 | CC= 0.50m FCL | Dra.no: 1 | 188 | 0 | 0.0 m\X\B3/h | Storey: 2 | 0.000000 l/h | .000 | .0002 | 270.000000 | Cooling Flow | CC= 2.80m FFB | 0.00 l/s | 0.0 Pa | 0.00 m/s | Pset_DDS - System Name: Cooling; Group: Cooling flow
2.2.0 | 00 Ground floor | CC= 2.80m SSL | NNUK=2.59 m | 2.80 m | NN=2.60 m | 02 | ins= 0.000000 mm | Hallway | Top= 0.49m FCL | Edge= 2.79m SSL | X=32.17 | Y=17.91 | 00.03 | CC= 0.50m FCL | Dra.no: 1 | 188 | 0 | 0.0 m\X\B3/h | Storey: 2 | 0.000000 l/h | .000 | .0002 | 270.000000 | Cooling Flow | CC= 2.80m FFB | 0.00 l/s | 0.0 Pa | 0.00 m/s | Pset_DDS - System Name: Cooling; Group: Cooling flow
2.2.0 | 00 Ground floor | CC= 2.90m SSL | NNUK=2.69 m | 2.90 m | NN=2.70 m | 02 | ins= 0.000000 mm | Hallway | Top= 0.39m FCL | Edge= 2.89m SSL | X=32.17 | Y=17.91 | 00.03 | CC= 0.40m FCL | Dra.no: 1 | 188 | 0 | 0.0 m\X\B3/h | Storey: 2 | 0.000000 l/h | .000 | .0002 | 90.000000 | Cooling Flow | CC= 2.90m FFB | 0.00 l/s | 0.0 Pa | 0.00 m/s | Pset_DDS - System Name: Cooling; Group: Cooling flow
2.2.0 | 00 Ground floor | CC= 2.90m SSL | NNUK=2.69 m | 2.90 m | NN=2.70 m | 02 | ins= 0.000000 mm | Hallway | Top= 0.39m FCL | Edge= 2.89m SSL | X=32.17 | Y=17.43 | 00.03 | CC= 0.40m FCL | Dra.no: 1 | 188 | 0 | 0.0 m\X\B3/h | Storey: 2 | 0.000000 l/h | .000 | .0002 | 90.000000 | Cooling Flow | CC= 2.90m FFB | 0.00 l/s | 0.0 Pa | 0.00 m/s | Pset_DDS - System Name: Cooling; Group: Cooling flow
2.2.0 | 00 Ground floor | CC= 2.80m SSL | NNUK=2.59 m | 2.80 m | NN=2.60 m | 02 | ins= 0.000000 mm | Hallway | Top= 0.49m FCL | Edge= 2.79m SSL | X=32.17 | Y=17.43 | 00.03 | CC= 0.50m FCL | Dra.no: 1 | 188 | 0 | 0.0 m\X\B3/h | Storey: 2 | 0.000000 l/h | .000 | .0002 | 270.000000 | Cooling Flow | CC= 2.80m FFB | 0.00 l/s | 0.0 Pa | 0.00 m/s | Pset_DDS - System Name: Cooling; Group: Cooling flow
2.5.2 | 00 Ground floor | CC= 2.75m SSL | NNUK=2.54 m | 2.75 m | NN=2.55 m | 02 | ins= 0.000000 mm | Hallway | Top= 0.54m FCL | Edge= 2.75m SSL | X=32.17 | Y=16.85 | 00.03 | CC= 0.55m FCL | Dra.no: 1 | 188 | 0 | 0.0 m\X\B3/h | Storey: 2 | 0.000000 l/h | .002 | .0005 | 90.000000 | Cooling Flow | CC= 2.75m FFB | 0.00 l/s | 0.0 Pa | 0.00 m/s | Pset_DDS - System Name: Cooling; Group: Cooling flow
2.5.3 | 00 Ground floor | CC= 2.75m SSL | NNUK=2.54 m | 2.75 m | NN=2.55 m | 02 | ins= 0.000000 mm | Hallway | Top= 0.54m FCL | Edge= 2.75m SSL | X=32.62 | Y=16.85 | 00.03 | CC= 0.55m FCL | Dra.no: 1 | 188 | 0 | 0.0 m\X\B3/h | Storey: 2 | 0.000000 l/h | .003 | .0005 | 270.000000 | Cooling Flow | CC= 2.75m FFB | 0.00 l/s | 0.0 Pa | 0.00 m/s | Pset_DDS - System Name: Cooling; Group: Cooling flow
2.5.4 | 00 Ground floor | CC= 3.10m SSL | NNUK=2.88 m | 3.10 m | NN=2.90 m | 02 | ins= 0.000000 mm | Hallway | Top= 0.19m FCL | Edge= 3.09m SSL | X=32.62 | Y=16.85 | 00.03 | CC= 0.20m FCL | Dra.no: 1 | 188 | 0 | 0.0 m\X\B3/h | Storey: 2 | 0.000000 l/h | .004 | .0005 | 90.000000 | Cooling Flow | CC= 3.10m FFB | 0.00 l/s | 0.0 Pa | 0.00 m/s | Pset_DDS - System Name: Cooling; Group: Cooling flow
3.5.2 | 00 Ground floor | CC= 2.80m SSL | NNUK=2.59 m | 2.80 m | NN=2.60 m | 03 | ins= 0.000000 mm | Hallway | Top= 0.49m FCL | Edge= 2.79m SSL | X=32.62 | Y=16.78 | 00.03 | CC= 0.50m FCL | Dra.no: 1 | 189 | 0 | 0.0 m\X\B3/h | Storey: 2 | 0.000000 l/h | .002 | .0005 | 270.000000 | Cooling return | CC= 2.80m FFB | 0.00 l/s | 0.0 Pa | 0.00 m/s | Pset_DDS - System Name: Cooling; Group: Cooling return
3.5.3 | 00 Ground floor | CC= 3.00m SSL | NNUK=2.79 m | 3.00 m | NN=2.80 m | 03 | ins= 0.000000 mm | Hallway | Top= 0.29m FCL | Edge= 2.99m SSL | X=32.62 | Y=16.78 | 00.03 | CC= 0.30m FCL | Dra.no: 1 | 189 | 0 | 0.0 m\X\B3/h | Storey: 2 | 0.000000 l/h | .003 | .0005 | 90.000000 | Cooling return | CC= 3.00m FFB | 0.00 l/s | 0.0 Pa | 0.00 m/s | Pset_DDS - System Name: Cooling; Group: Cooling return
2.1.12 | 02 Second floor | CC= 2.80m SSL | NNUK=9.59 m | 2.80 m | NN=9.60 m | 02 | ins= 9.000000 mm |  | Top= 0.00m FCL | Edge= 2.79m SSL | X=29.36 | Y=11.09 |  | CC= 0.50m FCL | Dra.no: 3 | 3 | 72106 | 2.5 m\X\B3/h | Storey: 4 | 2520.000011 l/h | .012 | .0001 | 90.000000 | Hotwater | CC= 2.80m FFB | 0.70 l/s | 276179.0 Pa | 2.20 m/s | Group: Hotwater; Pset_DDS - Insulation product text: Pipe insulation; Insulation product number: ZP150/918
3.1.17 | 02 Second floor | CC= 2.80m SSL | NNUK=9.59 m | 2.80 m | NN=9.60 m | 03 | ins= 9.000000 mm |  | Top= 0.00m FCL | Edge= 2.79m SSL | X=29.36 | Y=11.33 |  | CC= 0.50m FCL | Dra.no: 3 | 4 | 3343 | 0.3 m\X\B3/h | Storey: 4 | 282.908085 l/h | .017 | .0001 | 90.000000 | Circulation | CC= 2.80m FFB | 0.08 l/s | 5756.1 Pa | 0.39 m/s | Group: Circulation; Pset_DDS - Insulation product text: Pipe insulation; Insulation product number: ZP150/918
Bend | 00 Ground floor | CC= 0.09m SSL | NNUK=-0.12 m | 0.09 m | NN=-0.11 m | 00 | ins= 0.000000 mm | Office | Top= 3.20m FCL | Edge= 0.08m SSL | X=18.57 | Y=22.41 | 001 | CC= 3.21m FCL | Dra.no: 1 | 6 | 0 | 0.0 m\X\B3/h | Storey: 2 | 0.000000 l/h | .000 | .0000 | 270.000000 | Heat return | CC= 0.09m FFB | 0.00 l/s | 0.0 Pa | 0.00 m/s
Bend | 00 Ground floor | CC= 2.90m SSL | NNUK=2.69 m | 2.90 m | NN=2.70 m | 00 | ins= 0.000000 mm | Hallway | Top= 0.39m FCL | Edge= 2.89m SSL | X=32.23 | Y=17.43 | 00.03 | CC= 0.40m FCL | Dra.no: 1 | 189 | 0 | 0.0 m\X\B3/h | Storey: 2 | 0.000000 l/h | .000 | .0001 | 90.000000 | Cooling return | CC= 2.90m FFB | 0.00 l/s | 0.0 Pa | 0.00 m/s
Bend | 00 Ground floor | CC= 2.90m SSL | NNUK=2.69 m | 2.90 m | NN=2.70 m | 00 | ins= 0.000000 mm | Hallway | Top= 0.39m FCL | Edge= 2.89m SSL | X=32.23 | Y=17.91 | 00.03 | CC= 0.40m FCL | Dra.no: 1 | 189 | 0 | 0.0 m\X\B3/h | Storey: 2 | 0.000000 l/h | .000 | .0001 | 90.000000 | Cooling return | CC= 2.90m FFB | 0.00 l/s | 0.0 Pa | 0.00 m/s
Bend | 00 Ground floor | CC= 2.80m SSL | NNUK=2.59 m | 2.80 m | NN=2.60 m | 00 | ins= 0.000000 mm | Hallway | Top= 0.49m FCL | Edge= 2.79m SSL | X=32.23 | Y=17.91 | 00.03 | CC= 0.50m FCL | Dra.no: 1 | 189 | 0 | 0.0 m\X\B3/h | Storey: 2 | 0.000000 l/h | .000 | .0001 | 270.000000 | Cooling return | CC= 2.80m FFB | 0.00 l/s | 0.0 Pa | 0.00 m/s
Bend | 00 Ground floor | CC= 2.80m SSL | NNUK=2.59 m | 2.80 m | NN=2.60 m | 00 | ins= 0.000000 mm | Hallway | Top= 0.49m FCL | Edge= 2.79m SSL | X=32.23 | Y=18.49 | 00.03 | CC= 0.50m FCL | Dra.no: 1 | 189 | 0 | 0.0 m\X\B3/h | Storey: 2 | 0.000000 l/h | .000 | .0001 | 270.000000 | Cooling return | CC= 2.80m FFB | 0.00 l/s | 0.0 Pa | 0.00 m/s
Bend | 00 Ground floor | CC= 3.00m SSL | NNUK=2.79 m | 3.00 m | NN=2.80 m | 00 | ins= 0.000000 mm | Hallway | Top= 0.29m FCL | Edge= 2.99m SSL | X=32.23 | Y=18.49 | 00.03 | CC= 0.30m FCL | Dra.no: 1 | 189 | 0 | 0.0 m\X\B3/h | Storey: 2 | 0.000000 l/h | .000 | .0001 | 90.000000 | Cooling return | CC= 3.00m FFB | 0.00 l/s | 0.0 Pa | 0.00 m/s
Bend | 00 Ground floor | CC= -0.10m SSL | NNUK=-0.31 m | -0.10 m | NN=-0.30 m | 00 | ins= 0.000000 mm | Office | Top= 3.39m FCL | Edge= -0.11m SSL | X=18.57 | Y=22.41 | 001 | CC= 3.40m FCL | Dra.no: 1 | 6 | 0 | 0.0 m\X\B3/h | Storey: 2 | 0.000000 l/h | .000 | .0000 | 270.000000 | Heat return | CC= -0.10m FFB | 0.00 l/s | 0.0 Pa | 0.00 m/s
Bend | 00 Ground floor | CC= 0.09m SSL | NNUK=-0.12 m | 0.09 m | NN=-0.11 m | 00 | ins= 0.000000 mm | Office | Top= 3.20m FCL | Edge= 0.08m SSL | X=18.57 | Y=22.29 | 001 | CC= 3.21m FCL | Dra.no: 1 | 6 | 0 | 0.0 m\X\B3/h | Storey: 2 | 0.000000 l/h | .000 | .0000 | 270.000000 | Heat return | CC= 0.09m FFB | 0.00 l/s | 0.0 Pa | 0.00 m/s
Bend | 00 Ground floor | CC= 2.80m SSL | NNUK=2.59 m | 2.80 m | NN=2.60 m | 00 | ins= 0.000000 mm | Hallway | Top= 0.49m FCL | Edge= 2.79m SSL | X=32.23 | Y=17.43 | 00.03 | CC= 0.50m FCL | Dra.no: 1 | 189 | 0 | 0.0 m\X\B3/h | Storey: 2 | 0.000000 l/h | .000 | .0001 | 270.000000 | Cooling return | CC= 2.80m FFB | 0.00 l/s | 0.0 Pa | 0.00 m/s
Bend | 00 Ground floor | CC= 0.09m SSL | NNUK=-0.12 m | 0.09 m | NN=-0.11 m | 00 | ins= 0.000000 mm | Staircase | Top= 3.20m FCL | Edge= 0.08m SSL | X=7.32 | Y=22.29 | 00.05 | CC= 3.21m FCL | Dra.no: 1 | 6 | 0 | 0.0 m\X\B3/h | Storey: 2 | 0.000000 l/h | .000 | .0000 | 270.000000 | Heat return | CC= 0.09m FFB | 0.00 l/s | 0.0 Pa | 0.00 m/s
Bend | 00 Ground floor | CC= -0.20m SSL | NNUK=-0.41 m | -0.20 m | NN=-0.40 m | 00 | ins= 0.000000 mm | Staircase | Top= 3.49m FCL | Edge= -0.21m SSL | X=5.25 | Y=21.42 | 00.05 | CC= 3.50m FCL | Dra.no: 1 | 5 | 0 | 0.0 m\X\B3/h | Storey: 2 | 0.000000 l/h | .000 | .0000 | 270.000000 | Heat flow | CC= -0.20m FFB | 0.00 l/s | 0.0 Pa | 0.00 m/s
Bend | 00 Ground floor | CC= 0.21m SSL | NNUK=-0.12 m | 0.09 m | NN=-0.11 m | 00 | ins= 0.000000 mm | Office | Top= 3.08m FCL | Edge= 0.20m SSL | X=40.77 | Y=18.48 | 00.23 | CC= 3.09m FCL | Dra.no: 1 | 5 | 0 | 0.0 m\X\B3/h | Storey: 2 | 0.000000 l/h | .000 | .0000 | 270.000000 | Heat flow | CC= 0.21m FFB | 0.00 l/s | 0.0 Pa | 0.00 m/s
Bend | 00 Ground floor | CC= 0.09m SSL | NNUK=-0.12 m | 0.09 m | NN=-0.11 m | 00 | ins= 0.000000 mm | Staircase | Top= 3.20m FCL | Edge= 0.08m SSL | X=5.25 | Y=21.42 | 00.05 | CC= 3.21m FCL | Dra.no: 1 | 5 | 0 | 0.0 m\X\B3/h | Storey: 2 | 0.000000 l/h | .000 | .0000 | 270.000000 | Heat flow | CC= 0.09m FFB | 0.00 l/s | 0.0 Pa | 0.00 m/s
Bend | 00 Ground floor | CC= 0.09m SSL | NNUK=-0.12 m | 0.09 m | NN=-0.11 m | 00 | ins= 0.000000 mm | Staircase | Top= 3.20m FCL | Edge= 0.08m SSL | X=5.36 | Y=21.42 | 00.05 | CC= 3.21m FCL | Dra.no: 1 | 5 | 0 | 0.0 m\X\B3/h | Storey: 2 | 0.000000 l/h | .000 | .0000 | 270.000000 | Heat flow | CC= 0.09m FFB | 0.00 l/s | 0.0 Pa | 0.00 m/s
Bend | 00 Ground floor | CC= 0.21m SSL | NNUK=-0.12 m | 0.09 m | NN=-0.11 m | 00 | ins= 0.000000 mm | Office | Top= 3.08m FCL | Edge= 0.20m SSL | X=40.88 | Y=18.48 | 00.23 | CC= 3.09m FCL | Dra.no: 1 | 5 | 0 | 0.0 m\X\B3/h | Storey: 2 | 0.000000 l/h | .000 | .0000 | 270.000000 | Heat flow | CC= 0.21m FFB | 0.00 l/s | 0.0 Pa | 0.00 m/s
Bend | 00 Ground floor | CC= -0.10m SSL | NNUK=-0.31 m | -0.10 m | NN=-0.30 m | 00 | ins= 0.000000 mm | Staircase | Top= 3.39m FCL | Edge= -0.11m SSL | X=5.25 | Y=21.47 | 00.05 | CC= 3.40m FCL | Dra.no: 1 | 6 | 0 | 0.0 m\X\B3/h | Storey: 2 | 0.000000 l/h | .000 | .0000 | 270.000000 | Heat return | CC= -0.10m FFB | 0.00 l/s | 0.0 Pa | 0.00 m/s
Bend | 00 Ground floor | CC= -0.08m SSL | NNUK=-0.41 m | -0.20 m | NN=-0.40 m | 00 | ins= 0.000000 mm | Office | Top= 3.37m FCL | Edge= -0.09m SSL | X=40.88 | Y=18.48 | 00.23 | CC= 3.38m FCL | Dra.no: 1 | 5 | 0 | 0.0 m\X\B3/h | Storey: 2 | 0.000000 l/h | .000 | .0000 | 270.000000 | Heat flow | CC= -0.08m FFB | 0.00 l/s | 0.0 Pa | 0.00 m/s
Bend | 00 Ground floor | CC= 0.09m SSL | NNUK=-0.12 m | 0.09 m | NN=-0.11 m | 00 | ins= 0.000000 mm | Staircase | Top= 3.20m FCL | Edge= 0.08m SSL | X=5.25 | Y=21.47 | 00.05 | CC= 3.21m FCL | Dra.no: 1 | 6 | 0 | 0.0 m\X\B3/h | Storey: 2 | 0.000000 l/h | .000 | .0000 | 270.000000 | Heat return | CC= 0.09m FFB | 0.00 l/s | 0.0 Pa | 0.00 m/s
Bend | 00 Ground floor | CC= 0.09m SSL | NNUK=-0.12 m | 0.09 m | NN=-0.11 m | 00 | ins= 0.000000 mm | Staircase | Top= 3.20m FCL | Edge= 0.08m SSL | X=5.36 | Y=21.47 | 00.05 | CC= 3.21m FCL | Dra.no: 1 | 6 | 0 | 0.0 m\X\B3/h | Storey: 2 | 0.000000 l/h | .000 | .0000 | 270.000000 | Heat return | CC= 0.09m FFB | 0.00 l/s | 0.0 Pa | 0.00 m/s
Bend | 00 Ground floor | CC= 0.21m SSL | NNUK=-0.12 m | 0.09 m | NN=-0.11 m | 00 | ins= 0.000000 mm | Office | Top= 3.08m FCL | Edge= 0.20m SSL | X=38.00 | Y=22.29 | 00.23 | CC= 3.09m FCL | Dra.no: 1 | 6 | 0 | 0.0 m\X\B3/h | Storey: 2 | 0.000000 l/h | .000 | .0000 | 270.000000 | Heat return | CC= 0.21m FFB | 0.00 l/s | 0.0 Pa | 0.00 m/s
Bend | 00 Ground floor | CC= -0.08m SSL | NNUK=-0.41 m | -0.20 m | NN=-0.40 m | 00 | ins= 0.000000 mm | Storage | Top= 3.37m FCL | Edge= -0.09m SSL | X=40.88 | Y=12.71 | 00.12 | CC= 3.38m FCL | Dra.no: 1 | 5 | 0 | 0.0 m\X\B3/h | Storey: 2 | 0.000000 l/h | .000 | .0000 | 270.000000 | Heat flow | CC= -0.08m FFB | 0.00 l/s | 0.0 Pa | 0.00 m/s
Bend | 00 Ground floor | CC= 0.21m SSL | NNUK=-0.12 m | 0.09 m | NN=-0.11 m | 00 | ins= 0.000000 mm | Storage | Top= 3.08m FCL | Edge= 0.20m SSL | X=40.88 | Y=12.71 | 00.12 | CC= 3.09m FCL | Dra.no: 1 | 5 | 0 | 0.0 m\X\B3/h | Storey: 2 | 0.000000 l/h | .000 | .0000 | 270.000000 | Heat flow | CC= 0.21m FFB | 0.00 l/s | 0.0 Pa | 0.00 m/s
Bend | 00 Ground floor | CC= 0.21m SSL | NNUK=-0.12 m | 0.09 m | NN=-0.11 m | 00 | ins= 0.000000 mm | Office | Top= 3.08m FCL | Edge= 0.20m SSL | X=38.00 | Y=22.41 | 00.23 | CC= 3.09m FCL | Dra.no: 1 | 6 | 0 | 0.0 m\X\B3/h | Storey: 2 | 0.000000 l/h | .000 | .0000 | 270.000000 | Heat return | CC= 0.21m FFB | 0.00 l/s | 0.0 Pa | 0.00 m/s
Bend | 00 Ground floor | CC= 0.21m SSL | NNUK=-0.12 m | 0.09 m | NN=-0.11 m | 00 | ins= 0.000000 mm | Storage | Top= 3.08m FCL | Edge= 0.20m SSL | X=40.77 | Y=12.71 | 00.12 | CC= 3.09m FCL | Dra.no: 1 | 5 | 0 | 0.0 m\X\B3/h | Storey: 2 | 0.000000 l/h | .000 | .0000 | 270.000000 | Heat flow | CC= 0.21m FFB | 0.00 l/s | 0.0 Pa | 0.00 m/s
Bend | 00 Ground floor | CC= 0.02m SSL | NNUK=-0.31 m | -0.10 m | NN=-0.30 m | 00 | ins= 0.000000 mm | Office | Top= 3.27m FCL | Edge= 0.01m SSL | X=38.00 | Y=22.41 | 00.23 | CC= 3.28m FCL | Dra.no: 1 | 6 | 0 | 0.0 m\X\B3/h | Storey: 2 | 0.000000 l/h | .000 | .0000 | 270.000000 | Heat return | CC= 0.02m FFB | 0.00 l/s | 0.0 Pa | 0.00 m/s
Bend | 00 Ground floor | CC= 0.02m SSL | NNUK=-0.31 m | -0.10 m | NN=-0.30 m | 00 | ins= 0.000000 mm | Storage | Top= 3.27m FCL | Edge= 0.01m SSL | X=40.88 | Y=12.66 | 00.12 | CC= 3.28m FCL | Dra.no: 1 | 6 | 0 | 0.0 m\X\B3/h | Storey: 2 | 0.000000 l/h | .000 | .0000 | 270.000000 | Heat return | CC= 0.02m FFB | 0.00 l/s | 0.0 Pa | 0.00 m/s
Bend | 00 Ground floor | CC= 0.21m SSL | NNUK=-0.12 m | 0.09 m | NN=-0.11 m | 00 | ins= 0.000000 mm | Storage | Top= 3.08m FCL | Edge= 0.20m SSL | X=40.88 | Y=12.66 | 00.12 | CC= 3.09m FCL | Dra.no: 1 | 6 | 0 | 0.0 m\X\B3/h | Storey: 2 | 0.000000 l/h | .000 | .0000 | 270.000000 | Heat return | CC= 0.21m FFB | 0.00 l/s | 0.0 Pa | 0.00 m/s
Bend | 00 Ground floor | CC= 0.21m SSL | NNUK=-0.12 m | 0.09 m | NN=-0.11 m | 00 | ins= 0.000000 mm | Storage | Top= 3.08m FCL | Edge= 0.20m SSL | X=40.77 | Y=12.66 | 00.12 | CC= 3.09m FCL | Dra.no: 1 | 6 | 0 | 0.0 m\X\B3/h | Storey: 2 | 0.000000 l/h | .000 | .0000 | 270.000000 | Heat return | CC= 0.21m FFB | 0.00 l/s | 0.0 Pa | 0.00 m/s
Bend | 00 Ground floor | CC= 0.09m SSL | NNUK=-0.12 m | 0.09 m | NN=-0.11 m | 00 | ins= 0.000000 mm | Hallway | Top= 3.20m FCL | Edge= 0.08m SSL | X=27.62 | Y=22.25 | 00.03 | CC= 3.21m FCL | Dra.no: 1 | 6 | 0 | 0.0 m\X\B3/h | Storey: 2 | 0.000000 l/h | .000 | .0000 | 270.000000 | Heat return | CC= 0.09m FFB | 0.00 l/s | 0.0 Pa | 0.00 m/s
Bend | 00 Ground floor | CC= 0.02m SSL | NNUK=-0.31 m | -0.10 m | NN=-0.30 m | 00 | ins= 0.000000 mm | Director office | Top= 3.27m FCL | Edge= 0.01m SSL | X=38.30 | Y=6.95 | 00.24 | CC= 3.28m FCL | Dra.no: 1 | 6 | 0 | 0.0 m\X\B3/h | Storey: 2 | 0.000000 l/h | .000 | .0000 | 270.000000 | Heat return | CC= 0.02m FFB | 0.00 l/s | 0.0 Pa | 0.00 m/s
Bend | 00 Ground floor | CC= -0.20m SSL | NNUK=-0.41 m | -0.20 m | NN=-0.40 m | 00 | ins= 0.000000 mm | Hallway | Top= 3.49m FCL | Edge= -0.21m SSL | X=30.32 | Y=22.41 | 00.03 | CC= 3.50m FCL | Dra.no: 1 | 5 | 0 | 0.0 m\X\B3/h | Storey: 2 | 0.000000 l/h | .000 | .0000 | 270.000000 | Heat flow | CC= -0.20m FFB | 0.00 l/s | 0.0 Pa | 0.00 m/s
Bend | 00 Ground floor | CC= 0.09m SSL | NNUK=-0.12 m | 0.09 m | NN=-0.11 m | 00 | ins= 0.000000 mm | Hallway | Top= 3.20m FCL | Edge= 0.08m SSL | X=30.32 | Y=22.41 | 00.03 | CC= 3.21m FCL | Dra.no: 1 | 5 | 0 | 0.0 m\X\B3/h | Storey: 2 | 0.000000 l/h | .000 | .0000 | 270.000000 | Heat flow | CC= 0.09m FFB | 0.00 l/s | 0.0 Pa | 0.00 m/s
Bend | 00 Ground floor | CC= 0.09m SSL | NNUK=-0.12 m | 0.09 m | NN=-0.11 m | 00 | ins= 0.000000 mm | Hallway | Top= 3.20m FCL | Edge= 0.08m SSL | X=30.32 | Y=22.25 | 00.03 | CC= 3.21m FCL | Dra.no: 1 | 5 | 0 | 0.0 m\X\B3/h | Storey: 2 | 0.000000 l/h | .000 | .0000 | 270.000000 | Heat flow | CC= 0.09m FFB | 0.00 l/s | 0.0 Pa | 0.00 m/s
Bend | 00 Ground floor | CC= 0.21m SSL | NNUK=-0.12 m | 0.09 m | NN=-0.11 m | 00 | ins= 0.000000 mm | Director office | Top= 3.08m FCL | Edge= 0.20m SSL | X=38.35 | Y=7.06 | 00.24 | CC= 3.09m FCL | Dra.no: 1 | 5 | 0 | 0.0 m\X\B3/h | Storey: 2 | 0.000000 l/h | .000 | .0000 | 270.000000 | Heat flow | CC= 0.21m FFB | 0.00 l/s | 0.0 Pa | 0.00 m/s
Bend | 00 Ground floor | CC= -0.10m SSL | NNUK=-0.31 m | -0.10 m | NN=-0.30 m | 00 | ins= 0.000000 mm | Hallway | Top= 3.39m FCL | Edge= -0.11m SSL | X=30.37 | Y=22.41 | 00.03 | CC= 3.40m FCL | Dra.no: 1 | 6 | 0 | 0.0 m\X\B3/h | Storey: 2 | 0.000000 l/h | .000 | .0000 | 270.000000 | Heat return | CC= -0.10m FFB | 0.00 l/s | 0.0 Pa | 0.00 m/s
Bend | 00 Ground floor | CC= 0.21m SSL | NNUK=-0.12 m | 0.09 m | NN=-0.11 m | 00 | ins= 0.000000 mm | Director office | Top= 3.08m FCL | Edge= 0.20m SSL | X=38.35 | Y=6.95 | 00.24 | CC= 3.09m FCL | Dra.no: 1 | 5 | 0 | 0.0 m\X\B3/h | Storey: 2 | 0.000000 l/h | .000 | .0000 | 270.000000 | Heat flow | CC= 0.21m FFB | 0.00 l/s | 0.0 Pa | 0.00 m/s
Bend | 00 Ground floor | CC= 0.09m SSL | NNUK=-0.12 m | 0.09 m | NN=-0.11 m | 00 | ins= 0.000000 mm | Hallway | Top= 3.20m FCL | Edge= 0.08m SSL | X=30.37 | Y=22.41 | 00.03 | CC= 3.21m FCL | Dra.no: 1 | 6 | 0 | 0.0 m\X\B3/h | Storey: 2 | 0.000000 l/h | .000 | .0000 | 270.000000 | Heat return | CC= 0.09m FFB | 0.00 l/s | 0.0 Pa | 0.00 m/s
Bend | 00 Ground floor | CC= 0.09m SSL | NNUK=-0.12 m | 0.09 m | NN=-0.11 m | 00 | ins= 0.000000 mm | Hallway | Top= 3.20m FCL | Edge= 0.08m SSL | X=30.37 | Y=22.25 | 00.03 | CC= 3.21m FCL | Dra.no: 1 | 6 | 0 | 0.0 m\X\B3/h | Storey: 2 | 0.000000 l/h | .000 | .0000 | 270.000000 | Heat return | CC= 0.09m FFB | 0.00 l/s | 0.0 Pa | 0.00 m/s
Bend | 00 Ground floor | CC= -0.08m SSL | NNUK=-0.41 m | -0.20 m | NN=-0.40 m | 00 | ins= 0.000000 mm | Director office | Top= 3.37m FCL | Edge= -0.09m SSL | X=38.35 | Y=6.95 | 00.24 | CC= 3.38m FCL | Dra.no: 1 | 5 | 0 | 0.0 m\X\B3/h | Storey: 2 | 0.000000 l/h | .000 | .0000 | 270.000000 | Heat flow | CC= -0.08m FFB | 0.00 l/s | 0.0 Pa | 0.00 m/s
Bend | 00 Ground floor | CC= -0.20m SSL | NNUK=-0.41 m | -0.20 m | NN=-0.40 m | 00 | ins= 0.000000 mm | Staircase | Top= 3.49m FCL | Edge= -0.21m SSL | X=7.27 | Y=22.41 | 00.05 | CC= 3.50m FCL | Dra.no: 1 | 5 | 0 | 0.0 m\X\B3/h | Storey: 2 | 0.000000 l/h | .000 | .0000 | 270.000000 | Heat flow | CC= -0.20m FFB | 0.00 l/s | 0.0 Pa | 0.00 m/s
Bend | 00 Ground floor | CC= 0.09m SSL | NNUK=-0.12 m | 0.09 m | NN=-0.11 m | 00 | ins= 0.000000 mm | Staircase | Top= 3.20m FCL | Edge= 0.08m SSL | X=7.27 | Y=22.41 | 00.05 | CC= 3.21m FCL | Dra.no: 1 | 5 | 0 | 0.0 m\X\B3/h | Storey: 2 | 0.000000 l/h | .000 | .0000 | 270.000000 | Heat flow | CC= 0.09m FFB | 0.00 l/s | 0.0 Pa | 0.00 m/s
Bend | 00 Ground floor | CC= 0.21m SSL | NNUK=-0.12 m | 0.09 m | NN=-0.11 m | 00 | ins= 0.000000 mm | Office | Top= 3.08m FCL | Edge= 0.20m SSL | X=40.77 | Y=18.43 | 00.23 | CC= 3.09m FCL | Dra.no: 1 | 6 | 0 | 0.0 m\X\B3/h | Storey: 2 | 0.000000 l/h | .000 | .0000 | 270.000000 | Heat return | CC= 0.21m FFB | 0.00 l/s | 0.0 Pa | 0.00 m/s
Bend | 00 Ground floor | CC= 0.09m SSL | NNUK=-0.12 m | 0.09 m | NN=-0.11 m | 00 | ins= 0.000000 mm | Staircase | Top= 3.20m FCL | Edge= 0.08m SSL | X=7.27 | Y=22.29 | 00.05 | CC= 3.21m FCL | Dra.no: 1 | 5 | 0 | 0.0 m\X\B3/h | Storey: 2 | 0.000000 l/h | .000 | .0000 | 270.000000 | Heat flow | CC= 0.09m FFB | 0.00 l/s | 0.0 Pa | 0.00 m/s
Bend | 00 Ground floor | CC= 0.21m SSL | NNUK=-0.12 m | 0.09 m | NN=-0.11 m | 00 | ins= 0.000000 mm | Office | Top= 3.08m FCL | Edge= 0.20m SSL | X=40.88 | Y=18.43 | 00.23 | CC= 3.09m FCL | Dra.no: 1 | 6 | 0 | 0.0 m\X\B3/h | Storey: 2 | 0.000000 l/h | .000 | .0000 | 270.000000 | Heat return | CC= 0.21m FFB | 0.00 l/s | 0.0 Pa | 0.00 m/s
Bend | 00 Ground floor | CC= -0.10m SSL | NNUK=-0.31 m | -0.10 m | NN=-0.30 m | 00 | ins= 0.000000 mm | Staircase | Top= 3.39m FCL | Edge= -0.11m SSL | X=7.32 | Y=22.41 | 00.05 | CC= 3.40m FCL | Dra.no: 1 | 6 | 0 | 0.0 m\X\B3/h | Storey: 2 | 0.000000 l/h | .000 | .0000 | 270.000000 | Heat return | CC= -0.10m FFB | 0.00 l/s | 0.0 Pa | 0.00 m/s
Bend | 00 Ground floor | CC= 0.09m SSL | NNUK=-0.12 m | 0.09 m | NN=-0.11 m | 00 | ins= 0.000000 mm | Staircase | Top= 3.20m FCL | Edge= 0.08m SSL | X=7.32 | Y=22.41 | 00.05 | CC= 3.21m FCL | Dra.no: 1 | 6 | 0 | 0.0 m\X\B3/h | Storey: 2 | 0.000000 l/h | .000 | .0000 | 270.000000 | Heat return | CC= 0.09m FFB | 0.00 l/s | 0.0 Pa | 0.00 m/s
Bend | 00 Ground floor | CC= 0.02m SSL | NNUK=-0.31 m | -0.10 m | NN=-0.30 m | 00 | ins= 0.000000 mm | Office | Top= 3.27m FCL | Edge= 0.01m SSL | X=40.88 | Y=18.43 | 00.23 | CC= 3.28m FCL | Dra.no: 1 | 6 | 0 | 0.0 m\X\B3/h | Storey: 2 | 0.000000 l/h | .000 | .0000 | 270.000000 | Heat return | CC= 0.02m FFB | 0.00 l/s | 0.0 Pa | 0.00 m/s
Bend | 00 Ground floor | CC= -0.20m SSL | NNUK=-0.41 m | -0.20 m | NN=-0.40 m | 00 | ins= 0.000000 mm | Office | Top= 3.49m FCL | Edge= -0.21m SSL | X=16.27 | Y=22.41 | 00.21 | CC= 3.50m FCL | Dra.no: 1 | 5 | 0 | 0.0 m\X\B3/h | Storey: 2 | 0.000000 l/h | .000 | .0000 | 270.000000 | Heat flow | CC= -0.20m FFB | 0.00 l/s | 0.0 Pa | 0.00 m/s
Bend | 00 Ground floor | CC= -0.08m SSL | NNUK=-0.41 m | -0.20 m | NN=-0.40 m | 00 | ins= 0.000000 mm | Office | Top= 3.37m FCL | Edge= -0.09m SSL | X=35.39 | Y=22.41 | 00.23 | CC= 3.38m FCL | Dra.no: 1 | 5 | 0 | 0.0 m\X\B3/h | Storey: 2 | 0.000000 l/h | .000 | .0000 | 270.000000 | Heat flow | CC= -0.08m FFB | 0.00 l/s | 0.0 Pa | 0.00 m/s
Bend | 00 Ground floor | CC= 0.09m SSL | NNUK=-0.12 m | 0.09 m | NN=-0.11 m | 00 | ins= 0.000000 mm | Office | Top= 3.20m FCL | Edge= 0.08m SSL | X=16.27 | Y=22.41 | 00.21 | CC= 3.21m FCL | Dra.no: 1 | 5 | 0 | 0.0 m\X\B3/h | Storey: 2 | 0.000000 l/h | .000 | .0000 | 270.000000 | Heat flow | CC= 0.09m FFB | 0.00 l/s | 0.0 Pa | 0.00 m/s
Bend | 00 Ground floor | CC= 0.09m SSL | NNUK=-0.12 m | 0.09 m | NN=-0.11 m | 00 | ins= 0.000000 mm | Office | Top= 3.20m FCL | Edge= 0.08m SSL | X=16.27 | Y=22.29 | 00.21 | CC= 3.21m FCL | Dra.no: 1 | 5 | 0 | 0.0 m\X\B3/h | Storey: 2 | 0.000000 l/h | .000 | .0000 | 270.000000 | Heat flow | CC= 0.09m FFB | 0.00 l/s | 0.0 Pa | 0.00 m/s
Bend | 00 Ground floor | CC= 0.09m SSL | NNUK=-0.12 m | 0.09 m | NN=-0.11 m | 00 | ins= 0.000000 mm | Storage | Top= 3.20m FCL | Edge= 0.08m SSL | X=23.07 | Y=22.29 | 00.22 | CC= 3.21m FCL | Dra.no: 1 | 6 | 0 | 0.0 m\X\B3/h | Storey: 2 | 0.000000 l/h | .000 | .0000 | 270.000000 | Heat return | CC= 0.09m FFB | 0.00 l/s | 0.0 Pa | 0.00 m/s
Bend | 00 Ground floor | CC= -0.10m SSL | NNUK=-0.31 m | -0.10 m | NN=-0.30 m | 00 | ins= 0.000000 mm | Office | Top= 3.39m FCL | Edge= -0.11m SSL | X=16.32 | Y=22.41 | 00.21 | CC= 3.40m FCL | Dra.no: 1 | 6 | 0 | 0.0 m\X\B3/h | Storey: 2 | 0.000000 l/h | .000 | .0000 | 270.000000 | Heat return | CC= -0.10m FFB | 0.00 l/s | 0.0 Pa | 0.00 m/s
Bend | 00 Ground floor | CC= 0.09m SSL | NNUK=-0.12 m | 0.09 m | NN=-0.11 m | 00 | ins= 0.000000 mm | Office | Top= 3.20m FCL | Edge= 0.08m SSL | X=16.32 | Y=22.41 | 00.21 | CC= 3.21m FCL | Dra.no: 1 | 6 | 0 | 0.0 m\X\B3/h | Storey: 2 | 0.000000 l/h | .000 | .0000 | 270.000000 | Heat return | CC= 0.09m FFB | 0.00 l/s | 0.0 Pa | 0.00 m/s
Bend | 00 Ground floor | CC= 0.09m SSL | NNUK=-0.12 m | 0.09 m | NN=-0.11 m | 00 | ins= 0.000000 mm | Storage | Top= 3.20m FCL | Edge= 0.08m SSL | X=23.07 | Y=22.41 | 00.22 | CC= 3.21m FCL | Dra.no: 1 | 6 | 0 | 0.0 m\X\B3/h | Storey: 2 | 0.000000 l/h | .000 | .0000 | 270.000000 | Heat return | CC= 0.09m FFB | 0.00 l/s | 0.0 Pa | 0.00 m/s
Bend | 00 Ground floor | CC= 0.09m SSL | NNUK=-0.12 m | 0.09 m | NN=-0.11 m | 00 | ins= 0.000000 mm | Office | Top= 3.20m FCL | Edge= 0.08m SSL | X=16.32 | Y=22.29 | 00.21 | CC= 3.21m FCL | Dra.no: 1 | 6 | 0 | 0.0 m\X\B3/h | Storey: 2 | 0.000000 l/h | .000 | .0000 | 270.000000 | Heat return | CC= 0.09m FFB | 0.00 l/s | 0.0 Pa | 0.00 m/s
Bend | 00 Ground floor | CC= -0.10m SSL | NNUK=-0.31 m | -0.10 m | NN=-0.30 m | 00 | ins= 0.000000 mm | Storage | Top= 3.39m FCL | Edge= -0.11m SSL | X=23.07 | Y=22.41 | 00.22 | CC= 3.40m FCL | Dra.no: 1 | 6 | 0 | 0.0 m\X\B3/h | Storey: 2 | 0.000000 l/h | .000 | .0000 | 270.000000 | Heat return | CC= -0.10m FFB | 0.00 l/s | 0.0 Pa | 0.00 m/s
Bend | 00 Ground floor | CC= -0.20m SSL | NNUK=-0.41 m | -0.20 m | NN=-0.40 m | 00 | ins= 0.000000 mm | Office | Top= 3.49m FCL | Edge= -0.21m SSL | X=14.02 | Y=22.41 | 00.21 | CC= 3.50m FCL | Dra.no: 1 | 5 | 0 | 0.0 m\X\B3/h | Storey: 2 | 0.000000 l/h | .000 | .0000 | 270.000000 | Heat flow | CC= -0.20m FFB | 0.00 l/s | 0.0 Pa | 0.00 m/s
Bend | 00 Ground floor | CC= 0.09m SSL | NNUK=-0.12 m | 0.09 m | NN=-0.11 m | 00 | ins= 0.000000 mm | Office | Top= 3.20m FCL | Edge= 0.08m SSL | X=14.02 | Y=22.41 | 00.21 | CC= 3.21m FCL | Dra.no: 1 | 5 | 0 | 0.0 m\X\B3/h | Storey: 2 | 0.000000 l/h | .000 | .0000 | 270.000000 | Heat flow | CC= 0.09m FFB | 0.00 l/s | 0.0 Pa | 0.00 m/s
Bend | 00 Ground floor | CC= 0.09m SSL | NNUK=-0.12 m | 0.09 m | NN=-0.11 m | 00 | ins= 0.000000 mm | Office | Top= 3.20m FCL | Edge= 0.08m SSL | X=14.02 | Y=22.29 | 00.21 | CC= 3.21m FCL | Dra.no: 1 | 5 | 0 | 0.0 m\X\B3/h | Storey: 2 | 0.000000 l/h | .000 | .0000 | 270.000000 | Heat flow | CC= 0.09m FFB | 0.00 l/s | 0.0 Pa | 0.00 m/s
Bend | 00 Ground floor | CC= 0.09m SSL | NNUK=-0.12 m | 0.09 m | NN=-0.11 m | 00 | ins= 0.000000 mm | Storage | Top= 3.20m FCL | Edge= 0.08m SSL | X=23.02 | Y=22.29 | 00.22 | CC= 3.21m FCL | Dra.no: 1 | 5 | 0 | 0.0 m\X\B3/h | Storey: 2 | 0.000000 l/h | .000 | .0000 | 270.000000 | Heat flow | CC= 0.09m FFB | 0.00 l/s | 0.0 Pa | 0.00 m/s
