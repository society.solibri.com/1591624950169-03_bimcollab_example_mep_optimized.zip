Properties of the parts of a building model (IFC2X3), part 9 of 14

# IfcFlowSegment: SS091209003 (172)
Name | In | Material | Pset_FlowSegmentPipeSegment, Length (mm) | Mtg. Above Slab ref Center | Mounting Height | Pressure drop | Above Sea Level ref. Center | Main string number | Ins thickness | Mtg. Above Slab ref Bottom | Y | Mtg. Below Ceiling ref Center | Room tekst | Model Number | Layer number | Room number | Pset_DDS, Length | Floor number | Medium | X | Above Sea Level ref. Bottom | Flow (l/h) | Part number | Sub string number | Temperature | Mtg. Below Ceiling ref Top | Mtg. above Finished Floor ref Center | Peak flow (l/s) | Flow (l/s) | Abs. pressure | Velocity | Group | Insulation product text | Insulation product number | System Name
03.0002.04 | 00 Ground floor | ML-Copper pipes length 5 m 15x1 mm-Pipe insulation 9x15 mm gray insulation thickness 9 mm-9 | 1197.36 | CC= 3.25m SSL | 3.25 m | 2413 Pa | NN=3.05 m | 03 | ins= 9.000000 mm | Edge= 3.24m SSL | Y=15.07 | CC= 0.05m FCL | corridor | Dra.no: 1 | 4 | 00.04 | 1 | Storey: 2 | Circulation | X=21.83 | NNUK=3.04 m | 151.334382 l/h | .004 | .0002 | 61.39 \X\B0C | Top= 0.03m FCL | CC= 3.25m FFB | 0.00 l/s | 0.04 l/s | 2413.1 Pa | 0.32 m/s | Circulation | Pipe insulation | ZP150/915
03.0002.05 | 00 Ground floor | ML-Copper pipes length 5 m 15x1 mm-Pipe insulation 9x15 mm gray insulation thickness 9 mm-9 | 86.6102 | CC= 3.24m SSL | 3.24 m | 2413 Pa | NN=3.04 m | 03 | ins= 9.000000 mm | Edge= 3.24m SSL | Y=15.07 | CC= 0.06m FCL | wc | Dra.no: 1 | 4 | 00.09 | 0 | Storey: 2 | Circulation | X=23.04 | NNUK=3.04 m | 151.334382 l/h | .005 | .0002 | 61.39 \X\B0C | Top= 0.05m FCL | CC= 3.24m FFB | 0.00 l/s | 0.04 l/s | 2413.1 Pa | 0.32 m/s | Circulation | Pipe insulation | ZP150/915
03.0006.01 | 00 Ground floor | ML-Copper pipes length 5 m 15x1 mm | 3071.1 | CC= 3.12m SSL | 3.00 m | 0 Pa | NN=2.80 m | 03 | ins= 0.000000 mm | Edge= 3.11m SSL | Y=16.78 | CC= 0.18m FCL | Office | Dra.no: 1 | 189 | 00.23 | 3 | Storey: 2 | Cooling return | X=35.52 | NNUK=2.79 m | 0.000000 l/h | .001 | .0006 | 0.00 \X\B0C | Top= 0.17m FCL | CC= 3.12m FFB | 0.00 l/s | 0.00 l/s | 0.0 Pa | 0.00 m/s | Cooling return |  |  | Cooling
03.0006.02 | 00 Ground floor | ML-Copper pipes length 5 m 15x1 mm | 176.613 | CC= 3.12m SSL | 3.00 m | 0 Pa | NN=2.80 m | 03 | ins= 0.000000 mm | Edge= 3.11m SSL | Y=16.76 | CC= 0.18m FCL | Office | Dra.no: 1 | 189 | 00.23 | 0 | Storey: 2 | Cooling return | X=38.61 | NNUK=2.79 m | 0.000000 l/h | .002 | .0006 | 0.00 \X\B0C | Top= 0.17m FCL | CC= 3.12m FFB | 0.00 l/s | 0.00 l/s | 0.0 Pa | 0.00 m/s | Cooling return |  |  | Cooling
03.0006.03 | 00 Ground floor | ML-Copper pipes length 5 m 15x1 mm | 232 | CC= 3.10m SSL | 2.98 m | 0 Pa | NN=2.78 m | 03 | ins= 0.000000 mm | Edge= 3.10m SSL | Y=16.57 | CC= 0.20m FCL | Office | Dra.no: 1 | 189 | 00.23 | 0 | Storey: 2 | Cooling return | X=38.61 | NNUK=2.78 m | 0.000000 l/h | .003 | .0006 | 0.00 \X\B0C | Top= 0.19m FCL | CC= 3.10m FFB | 0.00 l/s | 0.00 l/s | 0.0 Pa | 0.00 m/s | Cooling return |  |  | Cooling
03.0007.00 | 00 Ground floor | ML-Copper pipes length 5 m 15x1 mm-Pipe insulation 9x15 mm gray insulation thickness 9 mm-9 | 232 | CC= 2.87m SSL | 2.75 m | 0 Pa | NN=2.55 m | 03 | ins= 9.000000 mm | Edge= 2.86m SSL | Y=16.57 | CC= 0.43m FCL | Office | Dra.no: 1 | 189 | 00.23 | 0 | Storey: 2 | Cooling return | X=35.49 | NNUK=2.54 m | 0.000000 l/h | .000 | .0007 | 0.00 \X\B0C | Top= 0.41m FCL | CC= 2.87m FFB | 0.00 l/s | 0.00 l/s | 0.0 Pa | 0.00 m/s | Cooling return | Pipe insulation | ZP150/915 | Cooling
03.0007.02 | 00 Ground floor | ML-Copper pipes length 5 m 15x1 mm-Pipe insulation 9x15 mm gray insulation thickness 9 mm-9 | 184.613 | CC= 3.12m SSL | 3.00 m | 0 Pa | NN=2.80 m | 03 | ins= 9.000000 mm | Edge= 3.11m SSL | Y=16.59 | CC= 0.18m FCL | Office | Dra.no: 1 | 189 | 00.23 | 0 | Storey: 2 | Cooling return | X=35.49 | NNUK=2.79 m | 0.000000 l/h | .002 | .0007 | 0.00 \X\B0C | Top= 0.16m FCL | CC= 3.12m FFB | 0.00 l/s | 0.00 l/s | 0.0 Pa | 0.00 m/s | Cooling return | Pipe insulation | ZP150/915 | Cooling
01.0003.00 | 01 First floor | ML-Copper pipes length 5 m 15x1 mm-Pipe insulation 9x15 mm gray insulation thickness 9 mm-9 | 336.25 | CC= 2.86m SSL | 2.86 m | 0 Pa | NN=6.16 m | 01 | ins= 9.000000 mm | Edge= 2.85m SSL | Y=10.94 | CC= 0.44m FCL |  | Dra.no: 2 | 2 |  | 0 | Storey: 3 | Coldwater | X=29.36 | NNUK=6.15 m | 0.000000 l/h | .000 | .0003 | 0.00 \X\B0C | Top= 0.00m FCL | CC= 2.86m FFB | 0.00 l/s | 0.00 l/s | 0.0 Pa | 0.00 m/s | Coldwater | Pipe insulation | ZP150/915 | PW
01.0006.00 | 01 First floor | ML-Copper pipes length 5 m 15x1 mm-Pipe insulation 9x15 mm gray insulation thickness 9 mm-9 | 3087.82 | CC= 2.67m SSL | 2.80 m | 13548 Pa | NN=6.10 m | 01 | ins= 9.000000 mm | Edge= 2.66m SSL | Y=10.94 | CC= 0.63m FCL | Restaurant | Dra.no: 2 | 2 | 01.03 | 3 | Storey: 3 | Coldwater | X=22.06 | NNUK=6.09 m | 935.999966 l/h | .000 | .0006 | 0.00 \X\B0C | Top= 0.62m FCL | CC= 2.67m FFB | 0.21 l/s | 0.26 l/s | 136144.2 Pa | 1.55 m/s | Coldwater | Pipe insulation | ZP150/915 | PW
01.0006.01 | 01 First floor | ML-Copper pipes length 5 m 15x1 mm-Pipe insulation 9x15 mm gray insulation thickness 9 mm-9 | 1272.14 | CC= 2.67m SSL | 2.80 m | 13548 Pa | NN=6.10 m | 01 | ins= 9.000000 mm | Edge= 2.66m SSL | Y=10.96 | CC= 0.63m FCL | Restaurant | Dra.no: 2 | 2 | 01.03 | 1 | Storey: 3 | Coldwater | X=18.95 | NNUK=6.09 m | 935.999966 l/h | .001 | .0006 | 0.00 \X\B0C | Top= 0.62m FCL | CC= 2.67m FFB | 0.21 l/s | 0.26 l/s | 136144.2 Pa | 1.55 m/s | Coldwater | Pipe insulation | ZP150/915 | PW
01.0007.00 | 01 First floor | ML-Copper pipes length 5 m 15x1 mm-Pipe insulation 9x15 mm gray insulation thickness 9 mm-9 | 1040.91 | CC= 2.67m SSL | 2.80 m | 3593 Pa | NN=6.10 m | 01 | ins= 9.000000 mm | Edge= 2.66m SSL | Y=12.25 | CC= 0.63m FCL | wc | Dra.no: 2 | 2 | 01.07 | 1 | Storey: 3 | Coldwater | X=18.95 | NNUK=6.09 m | 935.999966 l/h | .000 | .0007 | 0.00 \X\B0C | Top= 0.62m FCL | CC= 2.67m FFB | 0.21 l/s | 0.26 l/s | 122596.3 Pa | 1.55 m/s | Coldwater | Pipe insulation | ZP150/915 | PW
01.0008.00 | 01 First floor | ML-Copper pipes length 5 m 15x1 mm-Pipe insulation 9x15 mm gray insulation thickness 9 mm-9 | 1025.51 | CC= 2.67m SSL | 2.80 m | 119003 Pa | NN=6.10 m | 01 | ins= 9.000000 mm | Edge= 2.66m SSL | Y=13.32 | CC= 0.63m FCL | wc | Dra.no: 2 | 2 | 01.09 | 1 | Storey: 3 | Coldwater | X=18.95 | NNUK=6.09 m | 467.999983 l/h | .000 | .0008 | 0.00 \X\B0C | Top= 0.62m FCL | CC= 2.67m FFB | 0.13 l/s | 0.13 l/s | 119003.3 Pa | 0.98 m/s | Coldwater | Pipe insulation | ZP150/915 | PW
01.0008.00 | 01 First floor | ML-Copper pipes length 5 m 15x1 mm-Pipe insulation 9x15 mm gray insulation thickness 9 mm-9 | 47.1712 | CC= 0.76m SSL | 0.76 m | 119003 Pa | NN=4.06 m | 01 | ins= 9.000000 mm | Edge= 0.74m SSL | Y=14.43 | CC= 2.55m FCL |  | Dra.no: 2 | 2 |  | 0 | Storey: 3 | Coldwater | X=18.73 | NNUK=4.04 m | 467.999983 l/h | .000 | .0008 | 0.00 \X\B0C | Top= 0.00m FCL | CC= 0.76m FFB | 0.13 l/s | 0.13 l/s | 119003.3 Pa | 0.98 m/s | Coldwater | Pipe insulation | ZP150/915 | PW
01.0008.01 | 01 First floor | ML-Copper pipes length 5 m 15x1 mm-Pipe insulation 9x15 mm gray insulation thickness 9 mm-9 | 12 | CC= 2.67m SSL | 2.80 m | 119003 Pa | NN=6.10 m | 01 | ins= 9.000000 mm | Edge= 2.66m SSL | Y=14.36 | CC= 0.63m FCL | wc | Dra.no: 2 | 2 | 01.08 | 0 | Storey: 3 | Coldwater | X=18.94 | NNUK=6.09 m | 467.999983 l/h | .001 | .0008 | 0.00 \X\B0C | Top= 0.62m FCL | CC= 2.67m FFB | 0.13 l/s | 0.13 l/s | 119003.3 Pa | 0.98 m/s | Coldwater | Pipe insulation | ZP150/915 | PW
01.0008.02 | 01 First floor | ML-Copper pipes length 5 m 15x1 mm-Pipe insulation 9x15 mm gray insulation thickness 9 mm-9 | 13.7538 | CC= 0.76m SSL | 0.76 m | 119003 Pa | NN=4.06 m | 01 | ins= 9.000000 mm | Edge= 0.74m SSL | Y=14.36 | CC= 2.55m FCL |  | Dra.no: 2 | 2 |  | 0 | Storey: 3 | Coldwater | X=18.74 | NNUK=4.04 m | 467.999983 l/h | .002 | .0008 | 0.00 \X\B0C | Top= 0.00m FCL | CC= 0.76m FFB | 0.13 l/s | 0.13 l/s | 119003.3 Pa | 0.98 m/s | Coldwater | Pipe insulation | ZP150/915 | PW
01.0008.03 | 01 First floor | ML-Copper pipes length 5 m 15x1 mm-Pipe insulation 9x15 mm gray insulation thickness 9 mm-9 | 2009 | CC= 0.64m SSL | 0.77 m | 119003 Pa | NN=4.07 m | 01 | ins= 9.000000 mm | Edge= 0.63m SSL | Y=14.36 | CC= 2.66m FCL | wc | Dra.no: 2 | 2 | 01.08 | 2 | Storey: 3 | Coldwater | X=18.78 | NNUK=4.06 m | 467.999983 l/h | .003 | .0008 | 0.00 \X\B0C | Top= 2.64m FCL | CC= 0.64m FFB | 0.13 l/s | 0.13 l/s | 119003.3 Pa | 0.98 m/s | Coldwater | Pipe insulation | ZP150/915 | PW
01.0008.04 | 01 First floor | ML-Copper pipes length 5 m 15x1 mm-Pipe insulation 9x15 mm gray insulation thickness 9 mm-9 | 129.003 | CC= 2.67m SSL | 2.80 m | 119003 Pa | NN=6.10 m | 01 | ins= 9.000000 mm | Edge= 2.65m SSL | Y=14.36 | CC= 0.63m FCL | wc | Dra.no: 2 | 2 | 01.08 | 0 | Storey: 3 | Coldwater | X=18.79 | NNUK=6.09 m | 467.999983 l/h | .004 | .0008 | 0.00 \X\B0C | Top= 0.62m FCL | CC= 2.67m FFB | 0.13 l/s | 0.13 l/s | 119003.3 Pa | 0.98 m/s | Coldwater | Pipe insulation | ZP150/915 | PW
01.0009.00 | 01 First floor | ML-Copper pipes length 5 m 15x1 mm-Pipe insulation 9x15 mm gray insulation thickness 9 mm-9 | 42.943 | CC= 0.76m SSL | 0.76 m | 117642 Pa | NN=4.06 m | 01 | ins= 9.000000 mm | Edge= 0.74m SSL | Y=13.37 | CC= 2.55m FCL |  | Dra.no: 2 | 2 |  | 0 | Storey: 3 | Coldwater | X=18.73 | NNUK=4.04 m | 467.999983 l/h | .000 | .0009 | 0.00 \X\B0C | Top= 0.00m FCL | CC= 0.76m FFB | 0.13 l/s | 0.13 l/s | 117642.0 Pa | 0.98 m/s | Coldwater | Pipe insulation | ZP150/915 | PW
01.0009.02 | 01 First floor | ML-Copper pipes length 5 m 15x1 mm-Pipe insulation 9x15 mm gray insulation thickness 9 mm-9 | 13.0629 | CC= 0.76m SSL | 0.76 m | 117642 Pa | NN=4.06 m | 01 | ins= 9.000000 mm | Edge= 0.74m SSL | Y=13.31 | CC= 2.55m FCL |  | Dra.no: 2 | 2 |  | 0 | Storey: 3 | Coldwater | X=18.74 | NNUK=4.04 m | 467.999983 l/h | .002 | .0009 | 0.00 \X\B0C | Top= 0.00m FCL | CC= 0.76m FFB | 0.13 l/s | 0.13 l/s | 117642.0 Pa | 0.98 m/s | Coldwater | Pipe insulation | ZP150/915 | PW
01.0009.03 | 01 First floor | ML-Copper pipes length 5 m 15x1 mm-Pipe insulation 9x15 mm gray insulation thickness 9 mm-9 | 2009 | CC= 0.64m SSL | 0.77 m | 117642 Pa | NN=4.07 m | 01 | ins= 9.000000 mm | Edge= 0.63m SSL | Y=13.31 | CC= 2.66m FCL | wc | Dra.no: 2 | 2 | 01.09 | 2 | Storey: 3 | Coldwater | X=18.78 | NNUK=4.06 m | 467.999983 l/h | .003 | .0009 | 0.00 \X\B0C | Top= 2.64m FCL | CC= 0.64m FFB | 0.13 l/s | 0.13 l/s | 117642.0 Pa | 0.98 m/s | Coldwater | Pipe insulation | ZP150/915 | PW
01.0009.04 | 01 First floor | ML-Copper pipes length 5 m 15x1 mm-Pipe insulation 9x15 mm gray insulation thickness 9 mm-9 | 147.868 | CC= 2.67m SSL | 2.80 m | 117642 Pa | NN=6.10 m | 01 | ins= 9.000000 mm | Edge= 2.65m SSL | Y=13.31 | CC= 0.63m FCL | wc | Dra.no: 2 | 2 | 01.09 | 0 | Storey: 3 | Coldwater | X=18.79 | NNUK=6.09 m | 467.999983 l/h | .004 | .0009 | 0.00 \X\B0C | Top= 0.62m FCL | CC= 2.67m FFB | 0.13 l/s | 0.13 l/s | 117642.0 Pa | 0.98 m/s | Coldwater | Pipe insulation | ZP150/915 | PW
01.0013.00 | 01 First floor | ML-Copper pipes length 5 m 15x1 mm-Pipe insulation 9x15 mm gray insulation thickness 9 mm-9 | 693.397 | CC= 2.67m SSL | 2.80 m | 4225 Pa | NN=6.10 m | 01 | ins= 9.000000 mm | Edge= 2.66m SSL | Y=12.79 | CC= 0.63m FCL | corridor | Dra.no: 2 | 2 | 01.04 | 1 | Storey: 3 | Coldwater | X=22.16 | NNUK=6.09 m | 1223.999986 l/h | .000 | .0013 | 0.00 \X\B0C | Top= 0.62m FCL | CC= 2.67m FFB | 0.27 l/s | 0.34 l/s | 178791.0 Pa | 2.00 m/s | Coldwater | Pipe insulation | ZP150/915 | PW
01.0014.00 | 01 First floor | ML-Copper pipes length 5 m 15x1 mm-Pipe insulation 9x15 mm gray insulation thickness 9 mm-9 | 336.25 | CC= 2.67m SSL | 2.80 m | 2050 Pa | NN=6.10 m | 01 | ins= 9.000000 mm | Edge= 2.66m SSL | Y=13.51 | CC= 0.63m FCL | corridor | Dra.no: 2 | 2 | 01.04 | 0 | Storey: 3 | Coldwater | X=22.16 | NNUK=6.09 m | 971.999985 l/h | .000 | .0014 | 0.00 \X\B0C | Top= 0.62m FCL | CC= 2.67m FFB | 0.21 l/s | 0.27 l/s | 174566.3 Pa | 1.61 m/s | Coldwater | Pipe insulation | ZP150/915 | PW
01.0015.00 | 01 First floor | ML-Copper pipes length 5 m 15x1 mm-Pipe insulation 9x15 mm gray insulation thickness 9 mm-9 | 659.564 | CC= 2.67m SSL | 2.80 m | 1332 Pa | NN=6.10 m | 01 | ins= 9.000000 mm | Edge= 2.66m SSL | Y=13.87 | CC= 0.63m FCL | corridor | Dra.no: 2 | 2 | 01.04 | 1 | Storey: 3 | Coldwater | X=22.16 | NNUK=6.09 m | 504.000002 l/h | .000 | .0015 | 0.00 \X\B0C | Top= 0.62m FCL | CC= 2.67m FFB | 0.14 l/s | 0.14 l/s | 172516.1 Pa | 1.05 m/s | Coldwater | Pipe insulation | ZP150/915 | PW
01.0016.00 | 01 First floor | ML-Copper pipes length 5 m 15x1 mm-Pipe insulation 9x15 mm gray insulation thickness 9 mm-9 | 475.997 | CC= 2.67m SSL | 2.80 m | 171184 Pa | NN=6.10 m | 01 | ins= 9.000000 mm | Edge= 2.66m SSL | Y=14.56 | CC= 0.63m FCL | corridor | Dra.no: 2 | 2 | 01.04 | 0 | Storey: 3 | Coldwater | X=22.16 | NNUK=6.09 m | 252.000001 l/h | .000 | .0016 | 0.00 \X\B0C | Top= 0.62m FCL | CC= 2.67m FFB | 0.07 l/s | 0.07 l/s | 171184.2 Pa | 0.53 m/s | Coldwater | Pipe insulation | ZP150/915 | PW
01.0016.01 | 01 First floor | ML-Copper pipes length 5 m 15x1 mm-Pipe insulation 9x15 mm gray insulation thickness 9 mm-9 | 1112.94 | CC= 2.67m SSL | 2.80 m | 171184 Pa | NN=6.10 m | 01 | ins= 9.000000 mm | Edge= 2.66m SSL | Y=15.05 | CC= 0.63m FCL | corridor | Dra.no: 2 | 2 | 01.04 | 1 | Storey: 3 | Coldwater | X=22.17 | NNUK=6.09 m | 252.000001 l/h | .001 | .0016 | 0.00 \X\B0C | Top= 0.62m FCL | CC= 2.67m FFB | 0.07 l/s | 0.07 l/s | 171184.2 Pa | 0.53 m/s | Coldwater | Pipe insulation | ZP150/915 | PW
01.0016.02 | 01 First floor | ML-Copper pipes length 5 m 15x1 mm-Pipe insulation 9x15 mm gray insulation thickness 9 mm-9 | 98.6176 | CC= 2.67m SSL | 2.80 m | 171184 Pa | NN=6.10 m | 01 | ins= 9.000000 mm | Edge= 2.66m SSL | Y=15.07 | CC= 0.63m FCL | wc | Dra.no: 2 | 2 | 01.11 | 0 | Storey: 3 | Coldwater | X=23.31 | NNUK=6.09 m | 252.000001 l/h | .002 | .0016 | 0.00 \X\B0C | Top= 0.62m FCL | CC= 2.67m FFB | 0.07 l/s | 0.07 l/s | 171184.2 Pa | 0.53 m/s | Coldwater | Pipe insulation | ZP150/915 | PW
01.0016.03 | 01 First floor | ML-Copper pipes length 5 m 15x1 mm-Pipe insulation 9x15 mm gray insulation thickness 9 mm-9 | 2134 | CC= 2.65m SSL | 2.78 m | 171184 Pa | NN=6.08 m | 01 | ins= 9.000000 mm | Edge= 2.64m SSL | Y=15.18 | CC= 0.65m FCL | wc | Dra.no: 2 | 2 | 01.11 | 2 | Storey: 3 | Coldwater | X=23.31 | NNUK=6.07 m | 252.000001 l/h | .003 | .0016 | 0.00 \X\B0C | Top= 0.63m FCL | CC= 2.65m FFB | 0.07 l/s | 0.07 l/s | 171184.2 Pa | 0.53 m/s | Coldwater | Pipe insulation | ZP150/915 | PW
01.0016.04 | 01 First floor | ML-Copper pipes length 5 m 15x1 mm-Pipe insulation 9x15 mm gray insulation thickness 9 mm-9 | 2.69473 | CC= 0.50m SSL | 0.63 m | 171184 Pa | NN=3.93 m | 01 | ins= 9.000000 mm | Edge= 0.48m SSL | Y=15.17 | CC= 2.80m FCL | wc | Dra.no: 2 | 2 | 01.11 | 0 | Storey: 3 | Coldwater | X=23.31 | NNUK=3.92 m | 252.000001 l/h | .004 | .0016 | 0.00 \X\B0C | Top= 2.79m FCL | CC= 0.50m FFB | 0.07 l/s | 0.07 l/s | 171184.2 Pa | 0.53 m/s | Coldwater | Pipe insulation | ZP150/915 | PW
01.0017.00 | 01 First floor | ML-Copper pipes length 5 m 15x1 mm-Pipe insulation 9x15 mm gray insulation thickness 9 mm-9 | 2140 | CC= 2.66m SSL | 2.79 m | 170008 Pa | NN=6.09 m | 01 | ins= 9.000000 mm | Edge= 2.64m SSL | Y=14.54 | CC= 0.64m FCL | corridor | Dra.no: 2 | 2 | 01.04 | 2 | Storey: 3 | Coldwater | X=22.16 | NNUK=6.07 m | 252.000001 l/h | .000 | .0017 | 0.00 \X\B0C | Top= 0.63m FCL | CC= 2.66m FFB | 0.07 l/s | 0.07 l/s | 170007.6 Pa | 0.53 m/s | Coldwater | Pipe insulation | ZP150/915 | PW
01.0017.02 | 01 First floor | ML-Copper pipes length 5 m 15x1 mm-Pipe insulation 9x15 mm gray insulation thickness 9 mm-9 | 18.9884 | CC= 0.50m SSL | 0.63 m | 170008 Pa | NN=3.93 m | 01 | ins= 9.000000 mm | Edge= 0.48m SSL | Y=14.54 | CC= 2.80m FCL | corridor | Dra.no: 2 | 2 | 01.04 | 0 | Storey: 3 | Coldwater | X=22.14 | NNUK=3.92 m | 252.000001 l/h | .002 | .0017 | 0.00 \X\B0C | Top= 2.79m FCL | CC= 0.50m FFB | 0.07 l/s | 0.07 l/s | 170007.6 Pa | 0.53 m/s | Coldwater | Pipe insulation | ZP150/915 | PW
01.0018.00 | 01 First floor | ML-Copper pipes length 5 m 15x1 mm-Pipe insulation 9x15 mm gray insulation thickness 9 mm-9 | 45.2585 | CC= 0.76m SSL | 0.76 m | 117560 Pa | NN=4.06 m | 01 | ins= 9.000000 mm | Edge= 0.74m SSL | Y=13.92 | CC= 2.55m FCL |  | Dra.no: 2 | 2 |  | 0 | Storey: 3 | Coldwater | X=22.28 | NNUK=4.04 m | 467.999983 l/h | .000 | .0018 | 0.00 \X\B0C | Top= 0.00m FCL | CC= 0.76m FFB | 0.13 l/s | 0.13 l/s | 117559.8 Pa | 0.98 m/s | Coldwater | Pipe insulation | ZP150/915 | PW
01.0018.02 | 01 First floor | ML-Copper pipes length 5 m 15x1 mm-Pipe insulation 9x15 mm gray insulation thickness 9 mm-9 | 29.6402 | CC= 0.76m SSL | 0.76 m | 117560 Pa | NN=4.06 m | 01 | ins= 9.000000 mm | Edge= 0.74m SSL | Y=13.86 | CC= 2.55m FCL |  | Dra.no: 2 | 2 |  | 0 | Storey: 3 | Coldwater | X=22.26 | NNUK=4.04 m | 467.999983 l/h | .002 | .0018 | 0.00 \X\B0C | Top= 0.00m FCL | CC= 0.76m FFB | 0.13 l/s | 0.13 l/s | 117559.8 Pa | 0.98 m/s | Coldwater | Pipe insulation | ZP150/915 | PW
01.0018.03 | 01 First floor | ML-Copper pipes length 5 m 15x1 mm-Pipe insulation 9x15 mm gray insulation thickness 9 mm-9 | 2009 | CC= 0.77m SSL | 0.77 m | 117560 Pa | NN=4.07 m | 01 | ins= 9.000000 mm | Edge= 0.76m SSL | Y=13.86 | CC= 2.53m FCL |  | Dra.no: 2 | 2 |  | 2 | Storey: 3 | Coldwater | X=22.21 | NNUK=4.06 m | 467.999983 l/h | .003 | .0018 | 0.00 \X\B0C | Top= 0.00m FCL | CC= 0.77m FFB | 0.13 l/s | 0.13 l/s | 117559.8 Pa | 0.98 m/s | Coldwater | Pipe insulation | ZP150/915 | PW
01.0018.04 | 01 First floor | ML-Copper pipes length 5 m 15x1 mm-Pipe insulation 9x15 mm gray insulation thickness 9 mm-9 | 23.042 | CC= 2.80m SSL | 2.80 m | 117560 Pa | NN=6.10 m | 01 | ins= 9.000000 mm | Edge= 2.78m SSL | Y=13.86 | CC= 0.50m FCL |  | Dra.no: 2 | 2 |  | 0 | Storey: 3 | Coldwater | X=22.19 | NNUK=6.09 m | 467.999983 l/h | .004 | .0018 | 0.00 \X\B0C | Top= 0.00m FCL | CC= 2.80m FFB | 0.13 l/s | 0.13 l/s | 117559.8 Pa | 0.98 m/s | Coldwater | Pipe insulation | ZP150/915 | PW
01.0019.00 | 01 First floor | ML-Copper pipes length 5 m 15x1 mm-Pipe insulation 9x15 mm gray insulation thickness 9 mm-9 | 2140 | CC= 2.66m SSL | 2.79 m | 170008 Pa | NN=6.09 m | 01 | ins= 9.000000 mm | Edge= 2.64m SSL | Y=13.50 | CC= 0.64m FCL | corridor | Dra.no: 2 | 2 | 01.04 | 2 | Storey: 3 | Coldwater | X=22.16 | NNUK=6.07 m | 252.000001 l/h | .000 | .0019 | 0.00 \X\B0C | Top= 0.63m FCL | CC= 2.66m FFB | 0.07 l/s | 0.07 l/s | 170007.6 Pa | 0.53 m/s | Coldwater | Pipe insulation | ZP150/915 | PW
01.0019.02 | 01 First floor | ML-Copper pipes length 5 m 15x1 mm-Pipe insulation 9x15 mm gray insulation thickness 9 mm-9 | 18.9884 | CC= 0.50m SSL | 0.63 m | 170008 Pa | NN=3.93 m | 01 | ins= 9.000000 mm | Edge= 0.48m SSL | Y=13.50 | CC= 2.80m FCL | corridor | Dra.no: 2 | 2 | 01.04 | 0 | Storey: 3 | Coldwater | X=22.14 | NNUK=3.92 m | 252.000001 l/h | .002 | .0019 | 0.00 \X\B0C | Top= 2.79m FCL | CC= 0.50m FFB | 0.07 l/s | 0.07 l/s | 170007.6 Pa | 0.53 m/s | Coldwater | Pipe insulation | ZP150/915 | PW
01.0020.00 | 01 First floor | ML-Copper pipes length 5 m 15x1 mm-Pipe insulation 9x15 mm gray insulation thickness 9 mm-9 | 59.2324 | CC= 0.76m SSL | 0.76 m | 117584 Pa | NN=4.06 m | 01 | ins= 9.000000 mm | Edge= 0.74m SSL | Y=12.81 | CC= 2.55m FCL |  | Dra.no: 2 | 2 |  | 0 | Storey: 3 | Coldwater | X=22.28 | NNUK=4.04 m | 467.999983 l/h | .000 | .0020 | 0.00 \X\B0C | Top= 0.00m FCL | CC= 0.76m FFB | 0.13 l/s | 0.13 l/s | 117584.3 Pa | 0.98 m/s | Coldwater | Pipe insulation | ZP150/915 | PW
01.0020.02 | 01 First floor | ML-Copper pipes length 5 m 15x1 mm-Pipe insulation 9x15 mm gray insulation thickness 9 mm-9 | 29.6402 | CC= 0.76m SSL | 0.76 m | 117584 Pa | NN=4.06 m | 01 | ins= 9.000000 mm | Edge= 0.74m SSL | Y=12.73 | CC= 2.55m FCL |  | Dra.no: 2 | 2 |  | 0 | Storey: 3 | Coldwater | X=22.27 | NNUK=4.04 m | 467.999983 l/h | .002 | .0020 | 0.00 \X\B0C | Top= 0.00m FCL | CC= 0.76m FFB | 0.13 l/s | 0.13 l/s | 117584.3 Pa | 0.98 m/s | Coldwater | Pipe insulation | ZP150/915 | PW
01.0020.03 | 01 First floor | ML-Copper pipes length 5 m 15x1 mm-Pipe insulation 9x15 mm gray insulation thickness 9 mm-9 | 2009 | CC= 0.77m SSL | 0.77 m | 117584 Pa | NN=4.07 m | 01 | ins= 9.000000 mm | Edge= 0.76m SSL | Y=12.73 | CC= 2.53m FCL |  | Dra.no: 2 | 2 |  | 2 | Storey: 3 | Coldwater | X=22.22 | NNUK=4.06 m | 467.999983 l/h | .003 | .0020 | 0.00 \X\B0C | Top= 0.00m FCL | CC= 0.77m FFB | 0.13 l/s | 0.13 l/s | 117584.3 Pa | 0.98 m/s | Coldwater | Pipe insulation | ZP150/915 | PW
01.0020.04 | 01 First floor | ML-Copper pipes length 5 m 15x1 mm-Pipe insulation 9x15 mm gray insulation thickness 9 mm-9 | 33.6596 | CC= 2.80m SSL | 2.80 m | 117584 Pa | NN=6.10 m | 01 | ins= 9.000000 mm | Edge= 2.78m SSL | Y=12.73 | CC= 0.50m FCL |  | Dra.no: 2 | 2 |  | 0 | Storey: 3 | Coldwater | X=22.20 | NNUK=6.09 m | 467.999983 l/h | .004 | .0020 | 0.00 \X\B0C | Top= 0.00m FCL | CC= 2.80m FFB | 0.13 l/s | 0.13 l/s | 117584.3 Pa | 0.98 m/s | Coldwater | Pipe insulation | ZP150/915 | PW
01.0021.00 | 01 First floor | ML-Copper pipes length 5 m 15x1 mm-Pipe insulation 9x15 mm gray insulation thickness 9 mm-9 | 2142 | CC= 2.66m SSL | 2.79 m | 170008 Pa | NN=6.09 m | 01 | ins= 9.000000 mm | Edge= 2.65m SSL | Y=12.46 | CC= 0.64m FCL | corridor | Dra.no: 2 | 2 | 01.04 | 2 | Storey: 3 | Coldwater | X=22.16 | NNUK=6.08 m | 252.000001 l/h | .000 | .0021 | 0.00 \X\B0C | Top= 0.63m FCL | CC= 2.66m FFB | 0.07 l/s | 0.07 l/s | 170007.6 Pa | 0.53 m/s | Coldwater | Pipe insulation | ZP150/915 | PW
01.0021.02 | 01 First floor | ML-Copper pipes length 5 m 15x1 mm-Pipe insulation 9x15 mm gray insulation thickness 9 mm-9 | 18.9884 | CC= 0.50m SSL | 0.63 m | 170008 Pa | NN=3.93 m | 01 | ins= 9.000000 mm | Edge= 0.48m SSL | Y=12.46 | CC= 2.80m FCL | corridor | Dra.no: 2 | 2 | 01.04 | 0 | Storey: 3 | Coldwater | X=22.14 | NNUK=3.92 m | 252.000001 l/h | .002 | .0021 | 0.00 \X\B0C | Top= 2.79m FCL | CC= 0.50m FFB | 0.07 l/s | 0.07 l/s | 170007.6 Pa | 0.53 m/s | Coldwater | Pipe insulation | ZP150/915 | PW
01.0022.00 | 01 First floor | ML-Copper pipes length 5 m 15x1 mm-Pipe insulation 9x15 mm gray insulation thickness 9 mm-9 | 1030.57 | CC= 2.67m SSL | 2.80 m | 170652 Pa | NN=6.10 m | 01 | ins= 9.000000 mm | Edge= 2.66m SSL | Y=10.95 | CC= 0.63m FCL | Restaurant | Dra.no: 2 | 2 | 01.03 | 1 | Storey: 3 | Coldwater | X=23.11 | NNUK=6.09 m | 252.000001 l/h | .000 | .0022 | 0.00 \X\B0C | Top= 0.62m FCL | CC= 2.67m FFB | 0.07 l/s | 0.07 l/s | 170651.6 Pa | 0.53 m/s | Coldwater | Pipe insulation | ZP150/915 | PW
01.0022.02 | 01 First floor | ML-Copper pipes length 5 m 15x1 mm-Pipe insulation 9x15 mm gray insulation thickness 9 mm-9 | 2134 | CC= 2.65m SSL | 2.78 m | 170652 Pa | NN=6.08 m | 01 | ins= 9.000000 mm | Edge= 2.64m SSL | Y=12.00 | CC= 0.65m FCL | Restaurant | Dra.no: 2 | 2 | 01.03 | 2 | Storey: 3 | Coldwater | X=23.11 | NNUK=6.07 m | 252.000001 l/h | .002 | .0022 | 0.00 \X\B0C | Top= 0.63m FCL | CC= 2.65m FFB | 0.07 l/s | 0.07 l/s | 170651.6 Pa | 0.53 m/s | Coldwater | Pipe insulation | ZP150/915 | PW
01.0022.03 | 01 First floor | ML-Copper pipes length 5 m 15x1 mm-Pipe insulation 9x15 mm gray insulation thickness 9 mm-9 | 20.3017 | CC= 0.50m SSL | 0.63 m | 170652 Pa | NN=3.93 m | 01 | ins= 9.000000 mm | Edge= 0.48m SSL | Y=12.02 | CC= 2.80m FCL | wc | Dra.no: 2 | 2 | 01.10 | 0 | Storey: 3 | Coldwater | X=23.11 | NNUK=3.92 m | 252.000001 l/h | .003 | .0022 | 0.00 \X\B0C | Top= 2.79m FCL | CC= 0.50m FFB | 0.07 l/s | 0.07 l/s | 170651.6 Pa | 0.53 m/s | Coldwater | Pipe insulation | ZP150/915 | PW
02.0002.00 | 01 First floor | ML-Copper pipes length 5 m 15x1 mm-Pipe insulation 9x15 mm gray insulation thickness 9 mm-9 | 3111.25 | CC= 2.81m SSL | 2.81 m | 37075 Pa | NN=6.11 m | 02 | ins= 9.000000 mm | Edge= 2.80m SSL | Y=11.09 | CC= 0.49m FCL |  | Dra.no: 2 | 3 |  | 3 | Storey: 3 | Hotwater | X=29.36 | NNUK=6.10 m | 1260.000005 l/h | .000 | .0002 | 63.38 \X\B0C | Top= 0.00m FCL | CC= 2.81m FFB | 0.27 l/s | 0.35 l/s | 185479.5 Pa | 2.05 m/s | Hotwater | Pipe insulation | ZP150/915
02.0012.00 | 01 First floor | ML-Copper pipes length 5 m 15x1 mm-Pipe insulation 9x15 mm gray insulation thickness 9 mm-9 | 6036.6 | CC= 2.88m SSL | 2.88 m | 22082 Pa | NN=6.18 m | 02 | ins= 9.000000 mm | Edge= 2.86m SSL | Y=11.09 | CC= 0.43m FCL |  | Dra.no: 2 | 3 |  | 6 | Storey: 3 | Hotwater | X=29.35 | NNUK=6.16 m | 1260.000005 l/h | .000 | .0012 | 63.42 \X\B0C | Top= 0.00m FCL | CC= 2.88m FFB | 0.27 l/s | 0.35 l/s | 204073.1 Pa | 2.05 m/s | Hotwater | Pipe insulation | ZP150/915
02.0013.00 | 01 First floor | ML-Copper pipes length 5 m 15x1 mm-Pipe insulation 9x15 mm gray insulation thickness 9 mm-9 | 1232.07 | CC= 2.75m SSL | 2.88 m | 9246 Pa | NN=6.18 m | 02 | ins= 9.000000 mm | Edge= 2.73m SSL | Y=11.09 | CC= 0.56m FCL | Restaurant | Dra.no: 2 | 3 | 01.03 | 1 | Storey: 3 | Hotwater | X=23.29 | NNUK=6.16 m | 1008.000004 l/h | .000 | .0013 | 63.24 \X\B0C | Top= 0.54m FCL | CC= 2.75m FFB | 0.22 l/s | 0.28 l/s | 181991.0 Pa | 1.67 m/s | Hotwater | Pipe insulation | ZP150/915
02.0013.01 | 01 First floor | ML-Copper pipes length 5 m 15x1 mm-Pipe insulation 9x15 mm gray insulation thickness 9 mm-9 | 1536.58 | CC= 2.75m SSL | 2.88 m | 9246 Pa | NN=6.18 m | 02 | ins= 9.000000 mm | Edge= 2.73m SSL | Y=11.11 | CC= 0.56m FCL | Restaurant | Dra.no: 2 | 3 | 01.03 | 2 | Storey: 3 | Hotwater | X=22.04 | NNUK=6.16 m | 1008.000004 l/h | .001 | .0013 | 63.24 \X\B0C | Top= 0.54m FCL | CC= 2.75m FFB | 0.22 l/s | 0.28 l/s | 181991.0 Pa | 1.67 m/s | Hotwater | Pipe insulation | ZP150/915
02.0014.00 | 01 First floor | ML-Copper pipes length 5 m 15x1 mm-Pipe insulation 9x15 mm gray insulation thickness 9 mm-9 | 1019.33 | CC= 2.75m SSL | 2.88 m | 1833 Pa | NN=6.18 m | 02 | ins= 9.000000 mm | Edge= 2.73m SSL | Y=12.67 | CC= 0.56m FCL | corridor | Dra.no: 2 | 3 | 01.04 | 1 | Storey: 3 | Hotwater | X=22.04 | NNUK=6.16 m | 756.000003 l/h | .000 | .0014 | 63.17 \X\B0C | Top= 0.54m FCL | CC= 2.75m FFB | 0.16 l/s | 0.21 l/s | 172744.5 Pa | 1.21 m/s | Hotwater | Pipe insulation | ZP150/915
02.0015.00 | 01 First floor | ML-Copper pipes length 5 m 15x1 mm-Pipe insulation 9x15 mm gray insulation thickness 9 mm-9 | 1019.33 | CC= 2.75m SSL | 2.88 m | 1431 Pa | NN=6.18 m | 02 | ins= 9.000000 mm | Edge= 2.73m SSL | Y=13.71 | CC= 0.56m FCL | corridor | Dra.no: 2 | 3 | 01.04 | 1 | Storey: 3 | Hotwater | X=22.04 | NNUK=6.16 m | 504.000002 l/h | .000 | .0015 | 63.10 \X\B0C | Top= 0.54m FCL | CC= 2.75m FFB | 0.14 l/s | 0.14 l/s | 170911.6 Pa | 1.05 m/s | Hotwater | Pipe insulation | ZP150/915
02.0016.00 | 01 First floor | ML-Copper pipes length 5 m 15x1 mm-Pipe insulation 9x15 mm gray insulation thickness 9 mm-9 | 233.492 | CC= 2.75m SSL | 2.88 m | 949 Pa | NN=6.18 m | 02 | ins= 9.000000 mm | Edge= 2.73m SSL | Y=14.76 | CC= 0.56m FCL | corridor | Dra.no: 2 | 3 | 01.04 | 0 | Storey: 3 | Hotwater | X=22.04 | NNUK=6.16 m | 252.000001 l/h | .000 | .0016 | 63.01 \X\B0C | Top= 0.54m FCL | CC= 2.75m FFB | 0.07 l/s | 0.07 l/s | 169480.5 Pa | 0.53 m/s | Hotwater | Pipe insulation | ZP150/915
02.0016.01 | 01 First floor | ML-Copper pipes length 5 m 15x1 mm-Pipe insulation 9x15 mm gray insulation thickness 9 mm-9 | 1026.6 | CC= 2.75m SSL | 2.88 m | 949 Pa | NN=6.18 m | 02 | ins= 9.000000 mm | Edge= 2.73m SSL | Y=15.01 | CC= 0.56m FCL | corridor | Dra.no: 2 | 3 | 01.04 | 1 | Storey: 3 | Hotwater | X=22.06 | NNUK=6.16 m | 252.000001 l/h | .001 | .0016 | 63.01 \X\B0C | Top= 0.54m FCL | CC= 2.75m FFB | 0.07 l/s | 0.07 l/s | 169480.5 Pa | 0.53 m/s | Hotwater | Pipe insulation | ZP150/915
02.0016.02 | 01 First floor | ML-Copper pipes length 5 m 15x1 mm-Pipe insulation 9x15 mm gray insulation thickness 9 mm-9 | 73.4355 | CC= 2.75m SSL | 2.88 m | 949 Pa | NN=6.18 m | 02 | ins= 9.000000 mm | Edge= 2.73m SSL | Y=15.02 | CC= 0.56m FCL | wc | Dra.no: 2 | 3 | 01.11 | 0 | Storey: 3 | Hotwater | X=23.11 | NNUK=6.16 m | 252.000001 l/h | .002 | .0016 | 63.01 \X\B0C | Top= 0.54m FCL | CC= 2.75m FFB | 0.07 l/s | 0.07 l/s | 169480.5 Pa | 0.53 m/s | Hotwater | Pipe insulation | ZP150/915
02.0017.00 | 01 First floor | ML-Copper pipes length 5 m 15x1 mm-Pipe insulation 9x15 mm gray insulation thickness 9 mm-9 | 44.1989 | CC= 2.75m SSL | 2.88 m | 168531 Pa | NN=6.18 m | 02 | ins= 9.000000 mm | Edge= 2.73m SSL | Y=15.12 | CC= 0.56m FCL | wc | Dra.no: 2 | 3 | 01.11 | 0 | Storey: 3 | Hotwater | X=23.11 | NNUK=6.16 m | 252.000001 l/h | .000 | .0017 | 0.00 \X\B0C | Top= 0.54m FCL | CC= 2.75m FFB | 0.07 l/s | 0.07 l/s | 168531.1 Pa | 0.53 m/s | Hotwater | Pipe insulation | ZP150/915
02.0017.01 | 01 First floor | ML-Copper pipes length 5 m 15x1 mm-Pipe insulation 9x15 mm gray insulation thickness 9 mm-9 | 2209 | CC= 2.73m SSL | 2.86 m | 168531 Pa | NN=6.16 m | 02 | ins= 9.000000 mm | Edge= 2.71m SSL | Y=15.18 | CC= 0.57m FCL | wc | Dra.no: 2 | 3 | 01.11 | 2 | Storey: 3 | Hotwater | X=23.11 | NNUK=6.14 m | 252.000001 l/h | .001 | .0017 | 0.00 \X\B0C | Top= 0.56m FCL | CC= 2.73m FFB | 0.07 l/s | 0.07 l/s | 168531.1 Pa | 0.53 m/s | Hotwater | Pipe insulation | ZP150/915
02.0017.02 | 01 First floor | ML-Copper pipes length 5 m 15x1 mm-Pipe insulation 9x15 mm gray insulation thickness 9 mm-9 | 2.69473 | CC= 0.50m SSL | 0.63 m | 168531 Pa | NN=3.93 m | 02 | ins= 9.000000 mm | Edge= 0.48m SSL | Y=15.17 | CC= 2.80m FCL | wc | Dra.no: 2 | 3 | 01.11 | 0 | Storey: 3 | Hotwater | X=23.11 | NNUK=3.92 m | 252.000001 l/h | .002 | .0017 | 0.00 \X\B0C | Top= 2.79m FCL | CC= 0.50m FFB | 0.07 l/s | 0.07 l/s | 168531.1 Pa | 0.53 m/s | Hotwater | Pipe insulation | ZP150/915
02.0018.00 | 01 First floor | ML-Copper pipes length 5 m 15x1 mm-Pipe insulation 9x15 mm gray insulation thickness 9 mm-9 | 17 | CC= 2.76m SSL | 2.89 m | 168977 Pa | NN=6.19 m | 02 | ins= 9.000000 mm | Edge= 2.74m SSL | Y=14.74 | CC= 0.54m FCL | corridor | Dra.no: 2 | 3 | 01.04 | 0 | Storey: 3 | Hotwater | X=22.04 | NNUK=6.17 m | 252.000001 l/h | .000 | .0018 | 0.00 \X\B0C | Top= 0.53m FCL | CC= 2.76m FFB | 0.07 l/s | 0.07 l/s | 168977.1 Pa | 0.53 m/s | Hotwater | Pipe insulation | ZP150/915
02.0018.02 | 01 First floor | ML-Copper pipes length 5 m 15x1 mm-Pipe insulation 9x15 mm gray insulation thickness 9 mm-9 | 130.698 | CC= 2.79m SSL | 2.92 m | 168977 Pa | NN=6.22 m | 02 | ins= 9.000000 mm | Edge= 2.78m SSL | Y=14.74 | CC= 0.51m FCL | corridor | Dra.no: 2 | 3 | 01.04 | 0 | Storey: 3 | Hotwater | X=22.06 | NNUK=6.21 m | 252.000001 l/h | .002 | .0018 | 0.00 \X\B0C | Top= 0.49m FCL | CC= 2.79m FFB | 0.07 l/s | 0.07 l/s | 168977.1 Pa | 0.53 m/s | Hotwater | Pipe insulation | ZP150/915
02.0018.03 | 01 First floor | ML-Copper pipes length 5 m 15x1 mm-Pipe insulation 9x15 mm gray insulation thickness 9 mm-9 | 2256 | CC= 2.90m SSL | 2.90 m | 168977 Pa | NN=6.20 m | 02 | ins= 9.000000 mm | Edge= 2.89m SSL | Y=14.74 | CC= 0.40m FCL |  | Dra.no: 2 | 3 |  | 2 | Storey: 3 | Hotwater | X=22.21 | NNUK=6.19 m | 252.000001 l/h | .003 | .0018 | 0.00 \X\B0C | Top= 0.00m FCL | CC= 2.90m FFB | 0.07 l/s | 0.07 l/s | 168977.1 Pa | 0.53 m/s | Hotwater | Pipe insulation | ZP150/915
02.0018.04 | 01 First floor | ML-Copper pipes length 5 m 15x1 mm-Pipe insulation 9x15 mm gray insulation thickness 9 mm-9 | 71.5395 | CC= 0.63m SSL | 0.63 m | 168977 Pa | NN=3.93 m | 02 | ins= 9.000000 mm | Edge= 0.61m SSL | Y=14.74 | CC= 2.67m FCL |  | Dra.no: 2 | 3 |  | 0 | Storey: 3 | Hotwater | X=22.19 | NNUK=3.92 m | 252.000001 l/h | .004 | .0018 | 0.00 \X\B0C | Top= 0.00m FCL | CC= 0.63m FFB | 0.07 l/s | 0.07 l/s | 168977.1 Pa | 0.53 m/s | Hotwater | Pipe insulation | ZP150/915
02.0019.00 | 01 First floor | ML-Copper pipes length 5 m 15x1 mm-Pipe insulation 9x15 mm gray insulation thickness 9 mm-9 | 17 | CC= 2.76m SSL | 2.89 m | 168976 Pa | NN=6.19 m | 02 | ins= 9.000000 mm | Edge= 2.74m SSL | Y=13.70 | CC= 0.54m FCL | corridor | Dra.no: 2 | 3 | 01.04 | 0 | Storey: 3 | Hotwater | X=22.04 | NNUK=6.17 m | 252.000001 l/h | .000 | .0019 | 0.00 \X\B0C | Top= 0.53m FCL | CC= 2.76m FFB | 0.07 l/s | 0.07 l/s | 168975.5 Pa | 0.53 m/s | Hotwater | Pipe insulation | ZP150/915
02.0019.02 | 01 First floor | ML-Copper pipes length 5 m 15x1 mm-Pipe insulation 9x15 mm gray insulation thickness 9 mm-9 | 137.1 | CC= 2.79m SSL | 2.92 m | 168976 Pa | NN=6.22 m | 02 | ins= 9.000000 mm | Edge= 2.78m SSL | Y=13.70 | CC= 0.51m FCL | corridor | Dra.no: 2 | 3 | 01.04 | 0 | Storey: 3 | Hotwater | X=22.06 | NNUK=6.21 m | 252.000001 l/h | .002 | .0019 | 0.00 \X\B0C | Top= 0.49m FCL | CC= 2.79m FFB | 0.07 l/s | 0.07 l/s | 168975.5 Pa | 0.53 m/s | Hotwater | Pipe insulation | ZP150/915
02.0019.03 | 01 First floor | ML-Copper pipes length 5 m 15x1 mm-Pipe insulation 9x15 mm gray insulation thickness 9 mm-9 | 2256 | CC= 2.90m SSL | 2.90 m | 168976 Pa | NN=6.20 m | 02 | ins= 9.000000 mm | Edge= 2.89m SSL | Y=13.70 | CC= 0.40m FCL |  | Dra.no: 2 | 3 |  | 2 | Storey: 3 | Hotwater | X=22.22 | NNUK=6.19 m | 252.000001 l/h | .003 | .0019 | 0.00 \X\B0C | Top= 0.00m FCL | CC= 2.90m FFB | 0.07 l/s | 0.07 l/s | 168975.5 Pa | 0.53 m/s | Hotwater | Pipe insulation | ZP150/915
02.0019.04 | 01 First floor | ML-Copper pipes length 5 m 15x1 mm-Pipe insulation 9x15 mm gray insulation thickness 9 mm-9 | 78.3986 | CC= 0.63m SSL | 0.63 m | 168976 Pa | NN=3.93 m | 02 | ins= 9.000000 mm | Edge= 0.61m SSL | Y=13.70 | CC= 2.67m FCL |  | Dra.no: 2 | 3 |  | 0 | Storey: 3 | Hotwater | X=22.20 | NNUK=3.92 m | 252.000001 l/h | .004 | .0019 | 0.00 \X\B0C | Top= 0.00m FCL | CC= 0.63m FFB | 0.07 l/s | 0.07 l/s | 168975.5 Pa | 0.53 m/s | Hotwater | Pipe insulation | ZP150/915
02.0020.00 | 01 First floor | ML-Copper pipes length 5 m 15x1 mm-Pipe insulation 9x15 mm gray insulation thickness 9 mm-9 | 17 | CC= 2.76m SSL | 2.89 m | 168976 Pa | NN=6.19 m | 02 | ins= 9.000000 mm | Edge= 2.74m SSL | Y=12.66 | CC= 0.54m FCL | corridor | Dra.no: 2 | 3 | 01.04 | 0 | Storey: 3 | Hotwater | X=22.04 | NNUK=6.17 m | 252.000001 l/h | .000 | .0020 | 0.00 \X\B0C | Top= 0.53m FCL | CC= 2.76m FFB | 0.07 l/s | 0.07 l/s | 168976.0 Pa | 0.53 m/s | Hotwater | Pipe insulation | ZP150/915
02.0020.02 | 01 First floor | ML-Copper pipes length 5 m 15x1 mm-Pipe insulation 9x15 mm gray insulation thickness 9 mm-9 | 121.87 | CC= 2.79m SSL | 2.92 m | 168976 Pa | NN=6.22 m | 02 | ins= 9.000000 mm | Edge= 2.78m SSL | Y=12.66 | CC= 0.51m FCL | corridor | Dra.no: 2 | 3 | 01.04 | 0 | Storey: 3 | Hotwater | X=22.06 | NNUK=6.21 m | 252.000001 l/h | .002 | .0020 | 0.00 \X\B0C | Top= 0.49m FCL | CC= 2.79m FFB | 0.07 l/s | 0.07 l/s | 168976.0 Pa | 0.53 m/s | Hotwater | Pipe insulation | ZP150/915
02.0020.03 | 01 First floor | ML-Copper pipes length 5 m 15x1 mm-Pipe insulation 9x15 mm gray insulation thickness 9 mm-9 | 2256 | CC= 2.90m SSL | 2.90 m | 168976 Pa | NN=6.20 m | 02 | ins= 9.000000 mm | Edge= 2.89m SSL | Y=12.66 | CC= 0.40m FCL |  | Dra.no: 2 | 3 |  | 2 | Storey: 3 | Hotwater | X=22.20 | NNUK=6.19 m | 252.000001 l/h | .003 | .0020 | 0.00 \X\B0C | Top= 0.00m FCL | CC= 2.90m FFB | 0.07 l/s | 0.07 l/s | 168976.0 Pa | 0.53 m/s | Hotwater | Pipe insulation | ZP150/915
02.0020.04 | 01 First floor | ML-Copper pipes length 5 m 15x1 mm-Pipe insulation 9x15 mm gray insulation thickness 9 mm-9 | 63.6347 | CC= 0.63m SSL | 0.63 m | 168976 Pa | NN=3.93 m | 02 | ins= 9.000000 mm | Edge= 0.61m SSL | Y=12.66 | CC= 2.67m FCL |  | Dra.no: 2 | 3 |  | 0 | Storey: 3 | Hotwater | X=22.18 | NNUK=3.92 m | 252.000001 l/h | .004 | .0020 | 0.00 \X\B0C | Top= 0.00m FCL | CC= 0.63m FFB | 0.07 l/s | 0.07 l/s | 168976.0 Pa | 0.53 m/s | Hotwater | Pipe insulation | ZP150/915
02.0021.00 | 01 First floor | ML-Copper pipes length 5 m 15x1 mm-Pipe insulation 9x15 mm gray insulation thickness 9 mm-9 | 884.916 | CC= 2.75m SSL | 2.88 m | 168937 Pa | NN=6.18 m | 02 | ins= 9.000000 mm | Edge= 2.73m SSL | Y=11.10 | CC= 0.56m FCL | Restaurant | Dra.no: 2 | 3 | 01.03 | 1 | Storey: 3 | Hotwater | X=23.31 | NNUK=6.16 m | 252.000001 l/h | .000 | .0021 | 0.00 \X\B0C | Top= 0.54m FCL | CC= 2.75m FFB | 0.07 l/s | 0.07 l/s | 168937.4 Pa | 0.53 m/s | Hotwater | Pipe insulation | ZP150/915
02.0021.02 | 01 First floor | ML-Copper pipes length 5 m 15x1 mm-Pipe insulation 9x15 mm gray insulation thickness 9 mm-9 | 2209 | CC= 2.73m SSL | 2.86 m | 168937 Pa | NN=6.16 m | 02 | ins= 9.000000 mm | Edge= 2.71m SSL | Y=12.01 | CC= 0.57m FCL | wc | Dra.no: 2 | 3 | 01.10 | 2 | Storey: 3 | Hotwater | X=23.31 | NNUK=6.14 m | 252.000001 l/h | .002 | .0021 | 0.00 \X\B0C | Top= 0.56m FCL | CC= 2.73m FFB | 0.07 l/s | 0.07 l/s | 168937.4 Pa | 0.53 m/s | Hotwater | Pipe insulation | ZP150/915
02.0021.03 | 01 First floor | ML-Copper pipes length 5 m 15x1 mm-Pipe insulation 9x15 mm gray insulation thickness 9 mm-9 | 12 | CC= 0.50m SSL | 0.63 m | 168937 Pa | NN=3.93 m | 02 | ins= 9.000000 mm | Edge= 0.48m SSL | Y=12.02 | CC= 2.80m FCL | wc | Dra.no: 2 | 3 | 01.10 | 0 | Storey: 3 | Hotwater | X=23.31 | NNUK=3.92 m | 252.000001 l/h | .003 | .0021 | 0.00 \X\B0C | Top= 2.79m FCL | CC= 0.50m FFB | 0.07 l/s | 0.07 l/s | 168937.4 Pa | 0.53 m/s | Hotwater | Pipe insulation | ZP150/915
03.0002.00 | 01 First floor | ML-Copper pipes length 5 m 15x1 mm-Pipe insulation 9x15 mm gray insulation thickness 9 mm-9 | 3186.25 | CC= 2.89m SSL | 2.89 m | 2413 Pa | NN=6.19 m | 03 | ins= 9.000000 mm | Edge= 2.87m SSL | Y=11.33 | CC= 0.41m FCL |  | Dra.no: 2 | 4 |  | 3 | Storey: 3 | Circulation | X=29.36 | NNUK=6.17 m | 151.334382 l/h | .000 | .0002 | 61.39 \X\B0C | Top= 0.00m FCL | CC= 2.89m FFB | 0.00 l/s | 0.04 l/s | 2413.1 Pa | 0.32 m/s | Circulation | Pipe insulation | ZP150/915
03.0003.00 | 01 First floor | ML-Copper pipes length 5 m 15x1 mm-Pipe insulation 9x15 mm gray insulation thickness 9 mm-9 | 7503.51 | CC= 2.95m SSL | 2.95 m | 1391 Pa | NN=6.25 m | 03 | ins= 9.000000 mm | Edge= 2.94m SSL | Y=11.33 | CC= 0.35m FCL |  | Dra.no: 2 | 4 |  | 8 | Storey: 3 | Circulation | X=29.35 | NNUK=6.24 m | 131.573703 l/h | .000 | .0003 | 61.69 \X\B0C | Top= 0.00m FCL | CC= 2.95m FFB | 0.00 l/s | 0.04 l/s | 1390.9 Pa | 0.28 m/s | Circulation | Pipe insulation | ZP150/915
03.0003.02 | 01 First floor | ML-Copper pipes length 5 m 15x1 mm-Pipe insulation 9x15 mm gray insulation thickness 9 mm-9 | 3748.96 | CC= 2.82m SSL | 2.95 m | 1391 Pa | NN=6.25 m | 03 | ins= 9.000000 mm | Edge= 2.81m SSL | Y=11.34 | CC= 0.48m FCL | Restaurant | Dra.no: 2 | 4 | 01.03 | 4 | Storey: 3 | Circulation | X=21.83 | NNUK=6.24 m | 131.573703 l/h | .002 | .0003 | 61.69 \X\B0C | Top= 0.47m FCL | CC= 2.82m FFB | 0.00 l/s | 0.04 l/s | 1390.9 Pa | 0.28 m/s | Circulation | Pipe insulation | ZP150/915
03.0003.03 | 01 First floor | ML-Copper pipes length 5 m 15x1 mm-Pipe insulation 9x15 mm gray insulation thickness 9 mm-9 | 1237.44 | CC= 2.82m SSL | 2.95 m | 1391 Pa | NN=6.25 m | 03 | ins= 9.000000 mm | Edge= 2.81m SSL | Y=15.11 | CC= 0.48m FCL | corridor | Dra.no: 2 | 4 | 01.04 | 1 | Storey: 3 | Circulation | X=21.85 | NNUK=6.24 m | 131.573703 l/h | .003 | .0003 | 61.69 \X\B0C | Top= 0.47m FCL | CC= 2.82m FFB | 0.00 l/s | 0.04 l/s | 1390.9 Pa | 0.28 m/s | Circulation | Pipe insulation | ZP150/915
03.0003.04 | 01 First floor | ML-Copper pipes length 5 m 15x1 mm-Pipe insulation 9x15 mm gray insulation thickness 9 mm-9 | 45.2585 | CC= 2.80m SSL | 2.93 m | 1391 Pa | NN=6.23 m | 03 | ins= 9.000000 mm | Edge= 2.79m SSL | Y=15.11 | CC= 0.50m FCL | wc | Dra.no: 2 | 4 | 01.11 | 0 | Storey: 3 | Circulation | X=23.11 | NNUK=6.22 m | 131.573703 l/h | .004 | .0003 | 61.69 \X\B0C | Top= 0.48m FCL | CC= 2.80m FFB | 0.00 l/s | 0.04 l/s | 1390.9 Pa | 0.28 m/s | Circulation | Pipe insulation | ZP150/915
Pipe | 00 Ground floor | ML-Copper pipes length 5 m 15x1 mm-Pipe insulation 9x15 mm gray insulation thickness 9 mm-9 | 28.9939 | CC= 0.63m SSL | 0.63 m | 0 Pa | NN=0.43 m | 00 | ins= 9.000000 mm | Edge= 0.61m SSL | Y=12.46 | CC= 2.67m FCL | corridor | Dra.no: 1 | 2 | 00.04 | 0 | Storey: 2 | Coldwater | X=22.15 | NNUK=0.42 m | 0.000000 l/h | .000 | .0001 | 0.00 \X\B0C | Top= 2.65m FCL | CC= 0.63m FFB | 0.00 l/s | 0.00 l/s | 0.0 Pa | 0.00 m/s |  | Pipe insulation | ZP150/915
Pipe | 00 Ground floor | ML-Copper pipes length 5 m 15x1 mm-Pipe insulation 9x15 mm gray insulation thickness 9 mm-9 | 12 | CC= 3.19m SSL | 3.19 m | 0 Pa | NN=2.99 m | 00 | ins= 9.000000 mm | Edge= 3.17m SSL | Y=12.66 | CC= 0.11m FCL | corridor | Dra.no: 1 | 3 | 00.04 | 0 | Storey: 2 | Hotwater | X=21.91 | NNUK=2.97 m | 0.000000 l/h | .000 | .0001 | 0.00 \X\B0C | Top= 0.10m FCL | CC= 3.19m FFB | 0.00 l/s | 0.00 l/s | 0.0 Pa | 0.00 m/s |  | Pipe insulation | ZP150/915
Pipe | 00 Ground floor | ML-Copper pipes length 5 m 15x1 mm-Pipe insulation 9x15 mm gray insulation thickness 9 mm-9 | 213.452 | CC= 3.22m SSL | 3.22 m | 0 Pa | NN=3.02 m | 00 | ins= 9.000000 mm | Edge= 3.20m SSL | Y=12.66 | CC= 0.08m FCL | corridor | Dra.no: 1 | 3 | 00.04 | 0 | Storey: 2 | Hotwater | X=21.93 | NNUK=3.00 m | 0.000000 l/h | .000 | .0001 | 0.00 \X\B0C | Top= 0.07m FCL | CC= 3.22m FFB | 0.00 l/s | 0.00 l/s | 0.0 Pa | 0.00 m/s |  | Pipe insulation | ZP150/915
Pipe | 00 Ground floor | ML-Copper pipes length 5 m 15x1 mm-Pipe insulation 9x15 mm gray insulation thickness 9 mm-9 | 2551 | CC= 3.20m SSL | 3.20 m | 0 Pa | NN=3.00 m | 00 | ins= 9.000000 mm | Edge= 3.18m SSL | Y=12.66 | CC= 0.10m FCL | corridor | Dra.no: 1 | 3 | 00.04 | 3 | Storey: 2 | Hotwater | X=22.16 | NNUK=2.98 m | 0.000000 l/h | .000 | .0001 | 0.00 \X\B0C | Top= 0.09m FCL | CC= 3.20m FFB | 0.00 l/s | 0.00 l/s | 0.0 Pa | 0.00 m/s |  | Pipe insulation | ZP150/915
Pipe | 00 Ground floor | ML-Copper pipes length 5 m 15x1 mm-Pipe insulation 9x15 mm gray insulation thickness 9 mm-9 | 24.5634 | CC= 0.63m SSL | 0.63 m | 0 Pa | NN=0.43 m | 00 | ins= 9.000000 mm | Edge= 0.61m SSL | Y=12.66 | CC= 2.67m FCL | corridor | Dra.no: 1 | 3 | 00.04 | 0 | Storey: 2 | Hotwater | X=22.14 | NNUK=0.42 m | 0.000000 l/h | .000 | .0001 | 0.00 \X\B0C | Top= 2.65m FCL | CC= 0.63m FFB | 0.00 l/s | 0.00 l/s | 0.0 Pa | 0.00 m/s |  | Pipe insulation | ZP150/915
Pipe | 00 Ground floor | ML-Copper pipes length 5 m 15x1 mm-Pipe insulation 9x15 mm gray insulation thickness 9 mm-9 | 145.569 | CC= 3.10m SSL | 3.10 m | 0 Pa | NN=2.90 m | 00 | ins= 9.000000 mm | Edge= 3.09m SSL | Y=14.54 | CC= 0.20m FCL | corridor | Dra.no: 1 | 2 | 00.04 | 0 | Storey: 2 | Coldwater | X=22.00 | NNUK=2.89 m | 0.000000 l/h | .000 | .0001 | 0.00 \X\B0C | Top= 0.18m FCL | CC= 3.10m FFB | 0.00 l/s | 0.00 l/s | 0.0 Pa | 0.00 m/s |  | Pipe insulation | ZP150/915
Pipe | 00 Ground floor | ML-Copper pipes length 5 m 15x1 mm-Pipe insulation 9x15 mm gray insulation thickness 9 mm-9 | 2434 | CC= 3.08m SSL | 3.08 m | 0 Pa | NN=2.88 m | 00 | ins= 9.000000 mm | Edge= 3.07m SSL | Y=14.54 | CC= 0.22m FCL | corridor | Dra.no: 1 | 2 | 00.04 | 2 | Storey: 2 | Coldwater | X=22.17 | NNUK=2.87 m | 0.000000 l/h | .000 | .0001 | 0.00 \X\B0C | Top= 0.20m FCL | CC= 3.08m FFB | 0.00 l/s | 0.00 l/s | 0.0 Pa | 0.00 m/s |  | Pipe insulation | ZP150/915
Pipe | 00 Ground floor | ML-Copper pipes length 5 m 15x1 mm-Pipe insulation 9x15 mm gray insulation thickness 9 mm-9 | 27 | CC= 0.63m SSL | 0.63 m | 0 Pa | NN=0.43 m | 00 | ins= 9.000000 mm | Edge= 0.61m SSL | Y=14.54 | CC= 2.67m FCL | corridor | Dra.no: 1 | 2 | 00.04 | 0 | Storey: 2 | Coldwater | X=22.15 | NNUK=0.42 m | 0.000000 l/h | .000 | .0001 | 0.00 \X\B0C | Top= 2.65m FCL | CC= 0.63m FFB | 0.00 l/s | 0.00 l/s | 0.0 Pa | 0.00 m/s |  | Pipe insulation | ZP150/915
Pipe | 00 Ground floor | ML-Copper pipes length 5 m 15x1 mm-Pipe insulation 9x15 mm gray insulation thickness 9 mm-9 | 12 | CC= 3.19m SSL | 3.19 m | 0 Pa | NN=2.99 m | 00 | ins= 9.000000 mm | Edge= 3.17m SSL | Y=14.74 | CC= 0.11m FCL | corridor | Dra.no: 1 | 3 | 00.04 | 0 | Storey: 2 | Hotwater | X=21.91 | NNUK=2.97 m | 0.000000 l/h | .000 | .0001 | 0.00 \X\B0C | Top= 0.10m FCL | CC= 3.19m FFB | 0.00 l/s | 0.00 l/s | 0.0 Pa | 0.00 m/s |  | Pipe insulation | ZP150/915
Pipe | 00 Ground floor | ML-Copper pipes length 5 m 15x1 mm-Pipe insulation 9x15 mm gray insulation thickness 9 mm-9 | 215.411 | CC= 3.22m SSL | 3.22 m | 0 Pa | NN=3.02 m | 00 | ins= 9.000000 mm | Edge= 3.20m SSL | Y=14.74 | CC= 0.08m FCL | corridor | Dra.no: 1 | 3 | 00.04 | 0 | Storey: 2 | Hotwater | X=21.93 | NNUK=3.00 m | 0.000000 l/h | .000 | .0001 | 0.00 \X\B0C | Top= 0.07m FCL | CC= 3.22m FFB | 0.00 l/s | 0.00 l/s | 0.0 Pa | 0.00 m/s |  | Pipe insulation | ZP150/915
Pipe | 00 Ground floor | ML-Copper pipes length 5 m 15x1 mm-Pipe insulation 9x15 mm gray insulation thickness 9 mm-9 | 2551 | CC= 3.20m SSL | 3.20 m | 0 Pa | NN=3.00 m | 00 | ins= 9.000000 mm | Edge= 3.18m SSL | Y=14.74 | CC= 0.10m FCL | corridor | Dra.no: 1 | 3 | 00.04 | 3 | Storey: 2 | Hotwater | X=22.16 | NNUK=2.98 m | 0.000000 l/h | .000 | .0001 | 0.00 \X\B0C | Top= 0.09m FCL | CC= 3.20m FFB | 0.00 l/s | 0.00 l/s | 0.0 Pa | 0.00 m/s |  | Pipe insulation | ZP150/915
Pipe | 00 Ground floor | ML-Copper pipes length 5 m 15x1 mm-Pipe insulation 9x15 mm gray insulation thickness 9 mm-9 | 27 | CC= 0.63m SSL | 0.63 m | 0 Pa | NN=0.43 m | 00 | ins= 9.000000 mm | Edge= 0.61m SSL | Y=14.74 | CC= 2.67m FCL | corridor | Dra.no: 1 | 3 | 00.04 | 0 | Storey: 2 | Hotwater | X=22.15 | NNUK=0.42 m | 0.000000 l/h | .000 | .0001 | 0.00 \X\B0C | Top= 2.65m FCL | CC= 0.63m FFB | 0.00 l/s | 0.00 l/s | 0.0 Pa | 0.00 m/s |  | Pipe insulation | ZP150/915
Pipe | 00 Ground floor | ML-Copper pipes length 5 m 15x1 mm-Pipe insulation 9x15 mm gray insulation thickness 9 mm-9 | 149.45 | CC= 3.10m SSL | 3.10 m | 0 Pa | NN=2.90 m | 00 | ins= 9.000000 mm | Edge= 3.09m SSL | Y=13.50 | CC= 0.20m FCL | corridor | Dra.no: 1 | 2 | 00.04 | 0 | Storey: 2 | Coldwater | X=22.00 | NNUK=2.89 m | 0.000000 l/h | .000 | .0001 | 0.00 \X\B0C | Top= 0.18m FCL | CC= 3.10m FFB | 0.00 l/s | 0.00 l/s | 0.0 Pa | 0.00 m/s |  | Pipe insulation | ZP150/915
Pipe | 00 Ground floor | ML-Copper pipes length 5 m 15x1 mm-Pipe insulation 9x15 mm gray insulation thickness 9 mm-9 | 2434 | CC= 3.08m SSL | 3.08 m | 0 Pa | NN=2.88 m | 00 | ins= 9.000000 mm | Edge= 3.07m SSL | Y=13.50 | CC= 0.22m FCL | corridor | Dra.no: 1 | 2 | 00.04 | 2 | Storey: 2 | Coldwater | X=22.17 | NNUK=2.87 m | 0.000000 l/h | .000 | .0001 | 0.00 \X\B0C | Top= 0.20m FCL | CC= 3.08m FFB | 0.00 l/s | 0.00 l/s | 0.0 Pa | 0.00 m/s |  | Pipe insulation | ZP150/915
Pipe | 00 Ground floor | ML-Copper pipes length 5 m 15x1 mm-Pipe insulation 9x15 mm gray insulation thickness 9 mm-9 | 31.0754 | CC= 0.63m SSL | 0.63 m | 0 Pa | NN=0.43 m | 00 | ins= 9.000000 mm | Edge= 0.61m SSL | Y=13.50 | CC= 2.67m FCL | corridor | Dra.no: 1 | 2 | 00.04 | 0 | Storey: 2 | Coldwater | X=22.15 | NNUK=0.42 m | 0.000000 l/h | .000 | .0001 | 0.00 \X\B0C | Top= 2.65m FCL | CC= 0.63m FFB | 0.00 l/s | 0.00 l/s | 0.0 Pa | 0.00 m/s |  | Pipe insulation | ZP150/915
Pipe | 00 Ground floor | ML-Copper pipes length 5 m 15x1 mm-Pipe insulation 9x15 mm gray insulation thickness 9 mm-9 | 12 | CC= 3.19m SSL | 3.19 m | 0 Pa | NN=2.99 m | 00 | ins= 9.000000 mm | Edge= 3.17m SSL | Y=13.70 | CC= 0.11m FCL | corridor | Dra.no: 1 | 3 | 00.04 | 0 | Storey: 2 | Hotwater | X=21.91 | NNUK=2.97 m | 0.000000 l/h | .000 | .0001 | 0.00 \X\B0C | Top= 0.10m FCL | CC= 3.19m FFB | 0.00 l/s | 0.00 l/s | 0.0 Pa | 0.00 m/s |  | Pipe insulation | ZP150/915
Pipe | 00 Ground floor | ML-Copper pipes length 5 m 15x1 mm-Pipe insulation 9x15 mm gray insulation thickness 9 mm-9 | 216.118 | CC= 3.22m SSL | 3.22 m | 0 Pa | NN=3.02 m | 00 | ins= 9.000000 mm | Edge= 3.20m SSL | Y=13.70 | CC= 0.08m FCL | corridor | Dra.no: 1 | 3 | 00.04 | 0 | Storey: 2 | Hotwater | X=21.93 | NNUK=3.00 m | 0.000000 l/h | .000 | .0001 | 0.00 \X\B0C | Top= 0.07m FCL | CC= 3.22m FFB | 0.00 l/s | 0.00 l/s | 0.0 Pa | 0.00 m/s |  | Pipe insulation | ZP150/915
Pipe | 00 Ground floor | ML-Copper pipes length 5 m 15x1 mm-Pipe insulation 9x15 mm gray insulation thickness 9 mm-9 | 2551 | CC= 3.20m SSL | 3.20 m | 0 Pa | NN=3.00 m | 00 | ins= 9.000000 mm | Edge= 3.18m SSL | Y=13.70 | CC= 0.10m FCL | corridor | Dra.no: 1 | 3 | 00.04 | 3 | Storey: 2 | Hotwater | X=22.17 | NNUK=2.98 m | 0.000000 l/h | .000 | .0001 | 0.00 \X\B0C | Top= 0.09m FCL | CC= 3.20m FFB | 0.00 l/s | 0.00 l/s | 0.0 Pa | 0.00 m/s |  | Pipe insulation | ZP150/915
Pipe | 00 Ground floor | ML-Copper pipes length 5 m 15x1 mm-Pipe insulation 9x15 mm gray insulation thickness 9 mm-9 | 27 | CC= 0.63m SSL | 0.63 m | 0 Pa | NN=0.43 m | 00 | ins= 9.000000 mm | Edge= 0.61m SSL | Y=13.70 | CC= 2.67m FCL | corridor | Dra.no: 1 | 3 | 00.04 | 0 | Storey: 2 | Hotwater | X=22.15 | NNUK=0.42 m | 0.000000 l/h | .000 | .0001 | 0.00 \X\B0C | Top= 2.65m FCL | CC= 0.63m FFB | 0.00 l/s | 0.00 l/s | 0.0 Pa | 0.00 m/s |  | Pipe insulation | ZP150/915
Pipe | 00 Ground floor | ML-Copper pipes length 5 m 15x1 mm-Pipe insulation 9x15 mm gray insulation thickness 9 mm-9 | 149.693 | CC= 3.10m SSL | 3.10 m | 0 Pa | NN=2.90 m | 00 | ins= 9.000000 mm | Edge= 3.09m SSL | Y=12.46 | CC= 0.20m FCL | corridor | Dra.no: 1 | 2 | 00.04 | 0 | Storey: 2 | Coldwater | X=22.00 | NNUK=2.89 m | 0.000000 l/h | .000 | .0001 | 0.00 \X\B0C | Top= 0.18m FCL | CC= 3.10m FFB | 0.00 l/s | 0.00 l/s | 0.0 Pa | 0.00 m/s |  | Pipe insulation | ZP150/915
Pipe | 00 Ground floor | ML-Copper pipes length 5 m 15x1 mm-Pipe insulation 9x15 mm gray insulation thickness 9 mm-9 | 2434 | CC= 3.08m SSL | 3.08 m | 0 Pa | NN=2.88 m | 00 | ins= 9.000000 mm | Edge= 3.07m SSL | Y=12.46 | CC= 0.22m FCL | corridor | Dra.no: 1 | 2 | 00.04 | 2 | Storey: 2 | Coldwater | X=22.17 | NNUK=2.87 m | 0.000000 l/h | .000 | .0001 | 0.00 \X\B0C | Top= 0.20m FCL | CC= 3.08m FFB | 0.00 l/s | 0.00 l/s | 0.0 Pa | 0.00 m/s |  | Pipe insulation | ZP150/915
Pipe | 01 First floor | ML-Copper pipes length 5 m 15x1 mm-Pipe insulation 9x15 mm gray insulation thickness 9 mm-9 | 32 | CC= 0.76m SSL | 0.76 m | 0 Pa | NN=4.06 m | 00 | ins= 9.000000 mm | Edge= 0.74m SSL | Y=12.29 | CC= 2.55m FCL |  | Dra.no: 2 | 2 |  | 0 | Storey: 3 | Coldwater | X=18.73 | NNUK=4.04 m | 0.000000 l/h | .005 | .0000 | 0.00 \X\B0C | Top= 0.00m FCL | CC= 0.76m FFB | 0.00 l/s | 0.00 l/s | 0.0 Pa | 0.00 m/s |  | Pipe insulation | ZP150/915
Pipe | 01 First floor | ML-Copper pipes length 5 m 15x1 mm-Pipe insulation 9x15 mm gray insulation thickness 9 mm-9 | 13.7538 | CC= 0.76m SSL | 0.76 m | 0 Pa | NN=4.06 m | 00 | ins= 9.000000 mm | Edge= 0.74m SSL | Y=12.24 | CC= 2.55m FCL |  | Dra.no: 2 | 2 |  | 0 | Storey: 3 | Coldwater | X=18.75 | NNUK=4.04 m | 0.000000 l/h | .007 | .0000 | 0.00 \X\B0C | Top= 0.00m FCL | CC= 0.76m FFB | 0.00 l/s | 0.00 l/s | 0.0 Pa | 0.00 m/s |  | Pipe insulation | ZP150/915
Pipe | 01 First floor | ML-Copper pipes length 5 m 15x1 mm-Pipe insulation 9x15 mm gray insulation thickness 9 mm-9 | 2009 | CC= 0.64m SSL | 0.77 m | 0 Pa | NN=4.07 m | 00 | ins= 9.000000 mm | Edge= 0.63m SSL | Y=12.24 | CC= 2.66m FCL | wc | Dra.no: 2 | 2 | 01.07 | 2 | Storey: 3 | Coldwater | X=18.78 | NNUK=4.06 m | 0.000000 l/h | .008 | .0000 | 0.00 \X\B0C | Top= 2.64m FCL | CC= 0.64m FFB | 0.00 l/s | 0.00 l/s | 0.0 Pa | 0.00 m/s |  | Pipe insulation | ZP150/915
Pipe | 01 First floor | ML-Copper pipes length 5 m 15x1 mm-Pipe insulation 9x15 mm gray insulation thickness 9 mm-9 | 138.449 | CC= 2.67m SSL | 2.80 m | 0 Pa | NN=6.10 m | 00 | ins= 9.000000 mm | Edge= 2.65m SSL | Y=12.24 | CC= 0.63m FCL | wc | Dra.no: 2 | 2 | 01.07 | 0 | Storey: 3 | Coldwater | X=18.80 | NNUK=6.09 m | 0.000000 l/h | .009 | .0000 | 0.00 \X\B0C | Top= 0.62m FCL | CC= 2.67m FFB | 0.00 l/s | 0.00 l/s | 0.0 Pa | 0.00 m/s |  | Pipe insulation | ZP150/915

# IfcFlowSegment: SS091209004 (252)
Type - Description: Copper pipes length 5 m 18x1 mm; ApplicableOccurrence: Copper; PredefinedType: RIGIDSEGMENT
Type - Pset_ManufacturerTypeInformation - ArticleNumber: SS091209004; ModelReference: Copper pipes length 5 m 18x1 mm; Manufacturer: DDS
Type - Pset_PipeSegmentTypeCommon - NominalDiameter: 15; InnerDiameter: 16; OuterDiameter: 18
Pset_DDS - Flowsegment thickness: x1.0; Drain slope: 1:0; Manufacturer: DDS; Outside dimension: 18.000000; Drain slope (%): 10000.0 %; Project name: OpenBIM; Insulation WSVO: 0; Insulation k-value: 0; Drain Qww: Qww=0.00 l/s; Dimension DN: 15; Width: 15; Product: Copper pipes length 5 m 18x1 mm; Drain slope (\X\B0): 90.0\X\B0; Drain DU: DU=0.00 l/s; Product Number: SS091209004; Building Part: Building: 0
AC_Pset_RenovationAndPhasing - Renovation Status: Existing
Name | In | Material | Pset_FlowSegmentPipeSegment, Length (mm) | Mtg. Above Slab ref Center | Mounting Height | Pressure drop | Above Sea Level ref. Center | Main string number | Ins thickness | Mtg. Above Slab ref Bottom | Y | Mtg. Below Ceiling ref Center | Room tekst | Model Number | Layer number | Room number | Pset_DDS, Length | Floor number | Medium | Above Sea Level ref. Bottom | Flow (l/h) | Part number | Sub string number | Temperature | Mtg. Below Ceiling ref Top | Mtg. above Finished Floor ref Center | Peak flow (l/s) | Flow (l/s) | Abs. pressure | Velocity | X
01.0001.00 | 00 Ground floor | ML-Copper pipes length 5 m 18x1 mm | 21.9414 | CC= 3.12m SSL | 3.00 m | 0 Pa | NN=2.80 m | 01 | ins= 0.000000 mm | Edge= 3.11m SSL | Y=20.42 | CC= 0.18m FCL | Office | Dra.no: 1 | 189 | 00.23 | 0 | Storey: 2 | Cooling return | NNUK=2.79 m | 0.000000 l/h | .000 | .0001 | 0.00 \X\B0C | Top= 0.17m FCL | CC= 3.12m FFB | 0.00 l/s | 0.00 l/s | 0.0 Pa | 0.00 m/s | X=35.49 | Group: Cooling return
01.0001.00 | 00 Ground floor | ML-Copper pipes length 5 m 18x1 mm | 1878.54 | CC= 3.00m SSL | 3.00 m | 0 Pa | NN=2.80 m | 01 | ins= 0.000000 mm | Edge= 2.99m SSL | Y=18.51 | CC= 0.30m FCL | Hallway | Dra.no: 1 | 189 | 00.03 | 2 | Storey: 2 | Cooling return | NNUK=2.79 m | 0.000000 l/h | .000 | .0001 | 0.00 \X\B0C | Top= 0.29m FCL | CC= 3.00m FFB | 0.00 l/s | 0.00 l/s | 0.0 Pa | 0.00 m/s | X=32.23 | Group: Cooling return
01.0001.00 | 00 Ground floor | ML-Copper pipes length 5 m 18x1 mm | 54.5379 | CC= 2.82m SSL | 2.82 m | 0 Pa | NN=2.62 m | 01 | ins= 0.000000 mm | Edge= 2.81m SSL | Y=17.43 | CC= 0.48m FCL | Hallway | Dra.no: 1 | 189 | 00.03 | 0 | Storey: 2 | Cooling return | NNUK=2.62 m | 0.000000 l/h | .000 | .0001 | 0.00 \X\B0C | Top= 0.47m FCL | CC= 2.82m FFB | 0.00 l/s | 0.00 l/s | 0.0 Pa | 0.00 m/s | X=32.23 | Group: Cooling return
01.0001.00 | 00 Ground floor | ML-Copper pipes length 5 m 18x1 mm | 3225.29 | CC= 3.12m SSL | 3.00 m | 0 Pa | NN=2.80 m | 01 | ins= 0.000000 mm | Edge= 3.11m SSL | Y=20.42 | CC= 0.18m FCL | FB | Dra.no: 1 | 189 | 00.16 | 3 | Storey: 2 | Cooling return | NNUK=2.79 m | 0.000000 l/h | .000 | .0001 | 0.00 \X\B0C | Top= 0.17m FCL | CC= 3.12m FFB | 0.00 l/s | 0.00 l/s | 0.0 Pa | 0.00 m/s | X=32.25 | Group: Cooling return
01.0001.00 | 00 Ground floor | ML-Copper pipes length 5 m 18x1 mm | 442.12 | CC= 2.90m SSL | 2.90 m | 0 Pa | NN=2.70 m | 01 | ins= 0.000000 mm | Edge= 2.89m SSL | Y=17.45 | CC= 0.40m FCL | Hallway | Dra.no: 1 | 189 | 00.03 | 0 | Storey: 2 | Cooling return | NNUK=2.69 m | 0.000000 l/h | .000 | .0001 | 0.00 \X\B0C | Top= 0.39m FCL | CC= 2.90m FFB | 0.00 l/s | 0.00 l/s | 0.0 Pa | 0.00 m/s | X=32.23 | Group: Cooling return
01.0001.00 | 00 Ground floor | ML-Copper pipes length 5 m 18x1 mm | 54.5379 | CC= 2.88m SSL | 2.88 m | 0 Pa | NN=2.68 m | 01 | ins= 0.000000 mm | Edge= 2.87m SSL | Y=17.91 | CC= 0.42m FCL | Hallway | Dra.no: 1 | 189 | 00.03 | 0 | Storey: 2 | Cooling return | NNUK=2.67 m | 0.000000 l/h | .000 | .0001 | 0.00 \X\B0C | Top= 0.41m FCL | CC= 2.88m FFB | 0.00 l/s | 0.00 l/s | 0.0 Pa | 0.00 m/s | X=32.23 | Group: Cooling return
01.0001.00 | 00 Ground floor | ML-Copper pipes length 5 m 18x1 mm | 532.943 | CC= 2.80m SSL | 2.80 m | 0 Pa | NN=2.60 m | 01 | ins= 0.000000 mm | Edge= 2.79m SSL | Y=17.94 | CC= 0.50m FCL | Hallway | Dra.no: 1 | 189 | 00.03 | 1 | Storey: 2 | Cooling return | NNUK=2.59 m | 0.000000 l/h | .000 | .0001 | 0.00 \X\B0C | Top= 0.49m FCL | CC= 2.80m FFB | 0.00 l/s | 0.00 l/s | 0.0 Pa | 0.00 m/s | X=32.23 | Group: Cooling return
01.0001.00 | 00 Ground floor | ML-Copper pipes length 5 m 18x1 mm | 509.316 | CC= 2.80m SSL | 2.80 m | 0 Pa | NN=2.60 m | 01 | ins= 0.000000 mm | Edge= 2.79m SSL | Y=16.83 | CC= 0.50m FCL | Hallway | Dra.no: 1 | 189 | 00.03 | 1 | Storey: 2 | Cooling return | NNUK=2.59 m | 0.000000 l/h | .000 | .0001 | 0.00 \X\B0C | Top= 0.49m FCL | CC= 2.80m FFB | 0.00 l/s | 0.00 l/s | 0.0 Pa | 0.00 m/s | X=32.23 | Group: Cooling return
01.0001.00 | 00 Ground floor | ML-Copper pipes length 5 m 18x1 mm | 155.444 | CC= 2.82m SSL | 2.82 m | 0 Pa | NN=2.62 m | 01 | ins= 0.000000 mm | Edge= 2.81m SSL | Y=18.49 | CC= 0.48m FCL | Hallway | Dra.no: 1 | 189 | 00.03 | 0 | Storey: 2 | Cooling return | NNUK=2.62 m | 0.000000 l/h | .000 | .0001 | 0.00 \X\B0C | Top= 0.47m FCL | CC= 2.82m FFB | 0.00 l/s | 0.00 l/s | 0.0 Pa | 0.00 m/s | X=32.23 | Group: Cooling return
01.0001.00 | 00 Ground floor | ML-Copper pipes length 5 m 18x1 mm | 70.0306 | CC= 2.80m SSL | 2.80 m | 0 Pa | NN=2.60 m | 01 | ins= 0.000000 mm | Edge= 2.79m SSL | Y=17.33 | CC= 0.50m FCL | Hallway | Dra.no: 1 | 189 | 00.03 | 0 | Storey: 2 | Cooling return | NNUK=2.59 m | 0.000000 l/h | .000 | .0001 | 0.00 \X\B0C | Top= 0.49m FCL | CC= 2.80m FFB | 0.00 l/s | 0.00 l/s | 0.0 Pa | 0.00 m/s | X=32.23 | Group: Cooling return
01.0002.00 | 00 Ground floor | ML-Copper pipes length 5 m 18x1 mm-Pipe insulation 9x18 mm gray insulation thickness 9 mm-9 | 283 | CC= 3.04m SSL | 3.17 m | 16914 Pa | NN=2.97 m | 01 | ins= 9.000000 mm | Edge= 3.02m SSL | Y=10.94 | CC= 0.26m FCL | Shaft | Dra.no: 1 | 2 | 00.27 | 0 | Storey: 2 | Coldwater | NNUK=2.95 m | 3131.999937 l/h | .000 | .0002 | 0.00 \X\B0C | Top= 0.25m FCL | CC= 3.04m FFB | 0.50 l/s | 0.87 l/s | 244406.6 Pa | 2.49 m/s | X=29.36 | Group: Coldwater; Pset_DDS - Insulation product text: Pipe insulation; Insulation product number: ZP150/918; System Name: PW
01.0030.00 | 00 Ground floor | ML-Copper pipes length 5 m 18x1 mm-Pipe insulation 9x18 mm gray insulation thickness 9 mm-9 | 1497.74 | CC= 3.10m SSL | 3.10 m | 7829 Pa | NN=2.90 m | 01 | ins= 9.000000 mm | Edge= 3.08m SSL | Y=10.95 | CC= 0.40m FCL | Entrance | Dra.no: 1 | 2 | 00.01 | 1 | Storey: 2 | Coldwater | NNUK=2.88 m | 1943.999970 l/h | .000 | .0030 | 0.00 \X\B0C | Top= 0.38m FCL | CC= 3.10m FFB | 0.38 l/s | 0.54 l/s | 153729.6 Pa | 1.87 m/s | X=21.99 | Group: Coldwater; Pset_DDS - Insulation product text: Pipe insulation; Insulation product number: ZP150/918; System Name: PW
01.0030.00 | 00 Ground floor | ML-Copper pipes length 5 m 18x1 mm-Pipe insulation 9x18 mm gray insulation thickness 9 mm-9 | 287.466 | CC= 3.10m SSL | 3.10 m | 7829 Pa | NN=2.90 m | 01 | ins= 9.000000 mm | Edge= 3.08m SSL | Y=12.46 | CC= 0.20m FCL | corridor | Dra.no: 1 | 2 | 00.04 | 0 | Storey: 2 | Coldwater | NNUK=2.88 m | 1943.999970 l/h | .000 | .0030 | 0.00 \X\B0C | Top= 0.18m FCL | CC= 3.10m FFB | 0.38 l/s | 0.54 l/s | 153729.6 Pa | 1.87 m/s | X=21.99 | Group: Coldwater; Pset_DDS - Insulation product text: Pipe insulation; Insulation product number: ZP150/918; System Name: PW
01.0032.00 | 00 Ground floor | ML-Copper pipes length 5 m 18x1 mm-Pipe insulation 9x18 mm gray insulation thickness 9 mm-9 | 48.25 | CC= 3.10m SSL | 3.10 m | 4058 Pa | NN=2.90 m | 01 | ins= 9.000000 mm | Edge= 3.08m SSL | Y=12.77 | CC= 0.20m FCL | corridor | Dra.no: 1 | 2 | 00.04 | 0 | Storey: 2 | Coldwater | NNUK=2.88 m | 1223.999986 l/h | .000 | .0032 | 0.00 \X\B0C | Top= 0.18m FCL | CC= 3.10m FFB | 0.27 l/s | 0.34 l/s | 144299.1 Pa | 2.00 m/s | X=21.99 | Group: Coldwater; Pset_DDS - Insulation product text: Pipe insulation; Insulation product number: ZP150/918; System Name: PW
02.0002.00 | 00 Ground floor | ML-Copper pipes length 5 m 18x1 mm | 512.5 | CC= 2.80m SSL | 2.80 m | 0 Pa | NN=2.60 m | 02 | ins= 0.000000 mm | Edge= 2.79m SSL | Y=16.89 | CC= 0.50m FCL | Hallway | Dra.no: 1 | 188 | 00.03 | 1 | Storey: 2 | Cooling Flow | NNUK=2.59 m | 0.000000 l/h | .000 | .0002 | 0.00 \X\B0C | Top= 0.49m FCL | CC= 2.80m FFB | 0.00 l/s | 0.00 l/s | 0.0 Pa | 0.00 m/s | X=32.17 | Group: Cooling flow; Pset_DDS - System Name: Cooling
