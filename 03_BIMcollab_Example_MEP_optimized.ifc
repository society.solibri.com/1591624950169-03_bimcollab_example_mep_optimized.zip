Properties of the parts of a building model (IFC2X3), part 11 of 14

# IfcFlowSegment: SS091209004 (252)
Name | In | Material | Pset_FlowSegmentPipeSegment, Length (mm) | Mtg. Above Slab ref Center | Mounting Height | Pressure drop | Above Sea Level ref. Center | Main string number | Ins thickness | Mtg. Above Slab ref Bottom | Y | Mtg. Below Ceiling ref Center | Room tekst | Model Number | Layer number | Room number | Pset_DDS, Length | Floor number | Medium | Above Sea Level ref. Bottom | Flow (l/h) | Part number | Sub string number | Temperature | Mtg. Below Ceiling ref Top | Mtg. above Finished Floor ref Center | Peak flow (l/s) | Flow (l/s) | Abs. pressure | Velocity | X
Pipe | 00 Ground floor | ML-Copper pipes length 5 m 18x1 mm | 245 | CC= -0.18m SSL | -0.18 m | 0 Pa | NN=-0.38 m | 00 | ins= 0.000000 mm | Edge= -0.19m SSL | Y=22.41 | CC= 3.48m FCL | Office | Dra.no: 1 | 5 | 00.20 | 0 | Storey: 2 | Heat flow | NNUK=-0.38 m | 0.000000 l/h | .000 | .0000 | 0.00 \X\B0C | Top= 3.47m FCL | CC= -0.18m FFB | 0.00 l/s | 0.00 l/s | 0.0 Pa | 0.00 m/s | X=9.52
Pipe | 00 Ground floor | ML-Copper pipes length 5 m 18x1 mm | 265.569 | CC= -0.20m SSL | -0.20 m | 0 Pa | NN=-0.40 m | 00 | ins= 0.000000 mm | Edge= -0.21m SSL | Y=22.12 | CC= 3.50m FCL | Office | Dra.no: 1 | 5 | 00.20 | 0 | Storey: 2 | Heat flow | NNUK=-0.41 m | 0.000000 l/h | .000 | .0000 | 0.00 \X\B0C | Top= 3.49m FCL | CC= -0.20m FFB | 0.00 l/s | 0.00 l/s | 0.0 Pa | 0.00 m/s | X=9.52
Pipe | 00 Ground floor | ML-Copper pipes length 5 m 18x1 mm | 7.5 | CC= 0.11m SSL | 0.11 m | 0 Pa | NN=-0.09 m | 00 | ins= 0.000000 mm | Edge= 0.10m SSL | Y=22.29 | CC= 3.19m FCL | Office | Dra.no: 1 | 6 | 00.20 | 0 | Storey: 2 | Heat return | NNUK=-0.09 m | 0.000000 l/h | .000 | .0000 | 0.00 \X\B0C | Top= 3.18m FCL | CC= 0.11m FFB | 0.00 l/s | 0.00 l/s | 0.0 Pa | 0.00 m/s | X=11.82
Pipe | 00 Ground floor | ML-Copper pipes length 5 m 18x1 mm | 7.5 | CC= 0.11m SSL | 0.11 m | 0 Pa | NN=-0.09 m | 00 | ins= 0.000000 mm | Edge= 0.10m SSL | Y=22.25 | CC= 3.19m FCL | Hallway | Dra.no: 1 | 5 | 00.03 | 0 | Storey: 2 | Heat flow | NNUK=-0.09 m | 0.000000 l/h | .000 | .0000 | 0.00 \X\B0C | Top= 3.18m FCL | CC= 0.11m FFB | 0.00 l/s | 0.00 l/s | 0.0 Pa | 0.00 m/s | X=25.32
Pipe | 00 Ground floor | ML-Copper pipes length 5 m 18x1 mm | 113.5 | CC= 0.09m SSL | 0.09 m | 0 Pa | NN=-0.11 m | 00 | ins= 0.000000 mm | Edge= 0.08m SSL | Y=22.38 | CC= 3.21m FCL | Hallway | Dra.no: 1 | 5 | 00.03 | 0 | Storey: 2 | Heat flow | NNUK=-0.12 m | 0.000000 l/h | .000 | .0000 | 0.00 \X\B0C | Top= 3.20m FCL | CC= 0.09m FFB | 0.00 l/s | 0.00 l/s | 0.0 Pa | 0.00 m/s | X=25.32
Pipe | 00 Ground floor | ML-Copper pipes length 5 m 18x1 mm | 245 | CC= -0.18m SSL | -0.18 m | 0 Pa | NN=-0.38 m | 00 | ins= 0.000000 mm | Edge= -0.18m SSL | Y=22.41 | CC= 3.48m FCL | Hallway | Dra.no: 1 | 5 | 00.03 | 0 | Storey: 2 | Heat flow | NNUK=-0.38 m | 0.000000 l/h | .000 | .0000 | 0.00 \X\B0C | Top= 3.47m FCL | CC= -0.18m FFB | 0.00 l/s | 0.00 l/s | 0.0 Pa | 0.00 m/s | X=25.32
Pipe | 00 Ground floor | ML-Copper pipes length 5 m 18x1 mm | 265.569 | CC= -0.20m SSL | -0.20 m | 0 Pa | NN=-0.40 m | 00 | ins= 0.000000 mm | Edge= -0.21m SSL | Y=22.12 | CC= 3.50m FCL | Hallway | Dra.no: 1 | 5 | 00.03 | 0 | Storey: 2 | Heat flow | NNUK=-0.41 m | 0.000000 l/h | .000 | .0000 | 0.00 \X\B0C | Top= 3.49m FCL | CC= -0.20m FFB | 0.00 l/s | 0.00 l/s | 0.0 Pa | 0.00 m/s | X=25.32
Pipe | 00 Ground floor | ML-Copper pipes length 5 m 18x1 mm | 145 | CC= -0.08m SSL | -0.08 m | 0 Pa | NN=-0.28 m | 00 | ins= 0.000000 mm | Edge= -0.09m SSL | Y=22.41 | CC= 3.38m FCL | Staircase | Dra.no: 1 | 6 | 00.05 | 0 | Storey: 2 | Heat return | NNUK=-0.28 m | 0.000000 l/h | .000 | .0000 | 0.00 \X\B0C | Top= 3.37m FCL | CC= -0.08m FFB | 0.00 l/s | 0.00 l/s | 0.0 Pa | 0.00 m/s | X=7.32
Pipe | 00 Ground floor | ML-Copper pipes length 5 m 18x1 mm | 393.587 | CC= -0.10m SSL | -0.10 m | 0 Pa | NN=-0.30 m | 00 | ins= 0.000000 mm | Edge= -0.11m SSL | Y=21.99 | CC= 3.40m FCL | Staircase | Dra.no: 1 | 6 | 00.05 | 0 | Storey: 2 | Heat return | NNUK=-0.31 m | 0.000000 l/h | .000 | .0000 | 0.00 \X\B0C | Top= 3.39m FCL | CC= -0.10m FFB | 0.00 l/s | 0.00 l/s | 0.0 Pa | 0.00 m/s | X=7.32
Pipe | 00 Ground floor | ML-Copper pipes length 5 m 18x1 mm | 7.5 | CC= 0.11m SSL | 0.11 m | 0 Pa | NN=-0.09 m | 00 | ins= 0.000000 mm | Edge= 0.10m SSL | Y=22.29 | CC= 3.19m FCL | Staircase | Dra.no: 1 | 5 | 00.05 | 0 | Storey: 2 | Heat flow | NNUK=-0.09 m | 0.000000 l/h | .000 | .0000 | 0.00 \X\B0C | Top= 3.18m FCL | CC= 0.11m FFB | 0.00 l/s | 0.00 l/s | 0.0 Pa | 0.00 m/s | X=7.27
Pipe | 00 Ground floor | ML-Copper pipes length 5 m 18x1 mm | 65.9134 | CC= 0.09m SSL | 0.09 m | 0 Pa | NN=-0.11 m | 00 | ins= 0.000000 mm | Edge= 0.08m SSL | Y=22.38 | CC= 3.21m FCL | Staircase | Dra.no: 1 | 5 | 00.05 | 0 | Storey: 2 | Heat flow | NNUK=-0.12 m | 0.000000 l/h | .000 | .0000 | 0.00 \X\B0C | Top= 3.20m FCL | CC= 0.09m FFB | 0.00 l/s | 0.00 l/s | 0.0 Pa | 0.00 m/s | X=7.27
Pipe | 00 Ground floor | ML-Copper pipes length 5 m 18x1 mm | 245 | CC= -0.18m SSL | -0.18 m | 0 Pa | NN=-0.38 m | 00 | ins= 0.000000 mm | Edge= -0.19m SSL | Y=22.41 | CC= 3.48m FCL | Staircase | Dra.no: 1 | 5 | 00.05 | 0 | Storey: 2 | Heat flow | NNUK=-0.38 m | 0.000000 l/h | .000 | .0000 | 0.00 \X\B0C | Top= 3.47m FCL | CC= -0.18m FFB | 0.00 l/s | 0.00 l/s | 0.0 Pa | 0.00 m/s | X=7.27
Pipe | 00 Ground floor | ML-Copper pipes length 5 m 18x1 mm | 265.569 | CC= -0.20m SSL | -0.20 m | 0 Pa | NN=-0.40 m | 00 | ins= 0.000000 mm | Edge= -0.21m SSL | Y=22.12 | CC= 3.50m FCL | Staircase | Dra.no: 1 | 5 | 00.05 | 0 | Storey: 2 | Heat flow | NNUK=-0.41 m | 0.000000 l/h | .000 | .0000 | 0.00 \X\B0C | Top= 3.49m FCL | CC= -0.20m FFB | 0.00 l/s | 0.00 l/s | 0.0 Pa | 0.00 m/s | X=7.27
Pipe | 00 Ground floor | ML-Copper pipes length 5 m 18x1 mm | 7.5 | CC= 0.11m SSL | 0.11 m | 0 Pa | NN=-0.09 m | 00 | ins= 0.000000 mm | Edge= 0.10m SSL | Y=22.25 | CC= 3.19m FCL | Hallway | Dra.no: 1 | 6 | 00.03 | 0 | Storey: 2 | Heat return | NNUK=-0.09 m | 0.000000 l/h | .000 | .0000 | 0.00 \X\B0C | Top= 3.18m FCL | CC= 0.11m FFB | 0.00 l/s | 0.00 l/s | 0.0 Pa | 0.00 m/s | X=30.37
Pipe | 00 Ground floor | ML-Copper pipes length 5 m 18x1 mm | 113.5 | CC= 0.09m SSL | 0.09 m | 0 Pa | NN=-0.11 m | 00 | ins= 0.000000 mm | Edge= 0.08m SSL | Y=22.38 | CC= 3.21m FCL | Hallway | Dra.no: 1 | 6 | 00.03 | 0 | Storey: 2 | Heat return | NNUK=-0.12 m | 0.000000 l/h | .000 | .0000 | 0.00 \X\B0C | Top= 3.20m FCL | CC= 0.09m FFB | 0.00 l/s | 0.00 l/s | 0.0 Pa | 0.00 m/s | X=30.37
Pipe | 00 Ground floor | ML-Copper pipes length 5 m 18x1 mm | 145 | CC= -0.08m SSL | -0.08 m | 0 Pa | NN=-0.28 m | 00 | ins= 0.000000 mm | Edge= -0.08m SSL | Y=22.41 | CC= 3.38m FCL | Hallway | Dra.no: 1 | 6 | 00.03 | 0 | Storey: 2 | Heat return | NNUK=-0.28 m | 0.000000 l/h | .000 | .0000 | 0.00 \X\B0C | Top= 3.37m FCL | CC= -0.08m FFB | 0.00 l/s | 0.00 l/s | 0.0 Pa | 0.00 m/s | X=30.37
Pipe | 00 Ground floor | ML-Copper pipes length 5 m 18x1 mm | 405.587 | CC= -0.10m SSL | -0.10 m | 0 Pa | NN=-0.30 m | 00 | ins= 0.000000 mm | Edge= -0.11m SSL | Y=21.98 | CC= 3.40m FCL | Hallway | Dra.no: 1 | 6 | 00.03 | 0 | Storey: 2 | Heat return | NNUK=-0.31 m | 0.000000 l/h | .000 | .0000 | 0.00 \X\B0C | Top= 3.39m FCL | CC= -0.10m FFB | 0.00 l/s | 0.00 l/s | 0.0 Pa | 0.00 m/s | X=30.37
Pipe | 00 Ground floor | ML-Copper pipes length 5 m 18x1 mm | 7.5 | CC= 0.11m SSL | 0.11 m | 0 Pa | NN=-0.09 m | 00 | ins= 0.000000 mm | Edge= 0.10m SSL | Y=22.25 | CC= 3.19m FCL | Hallway | Dra.no: 1 | 5 | 00.03 | 0 | Storey: 2 | Heat flow | NNUK=-0.09 m | 0.000000 l/h | .000 | .0000 | 0.00 \X\B0C | Top= 3.18m FCL | CC= 0.11m FFB | 0.00 l/s | 0.00 l/s | 0.0 Pa | 0.00 m/s | X=30.32
Pipe | 00 Ground floor | ML-Copper pipes length 5 m 18x1 mm | 113.5 | CC= 0.09m SSL | 0.09 m | 0 Pa | NN=-0.11 m | 00 | ins= 0.000000 mm | Edge= 0.08m SSL | Y=22.38 | CC= 3.21m FCL | Hallway | Dra.no: 1 | 5 | 00.03 | 0 | Storey: 2 | Heat flow | NNUK=-0.12 m | 0.000000 l/h | .000 | .0000 | 0.00 \X\B0C | Top= 3.20m FCL | CC= 0.09m FFB | 0.00 l/s | 0.00 l/s | 0.0 Pa | 0.00 m/s | X=30.32
Pipe | 00 Ground floor | ML-Copper pipes length 5 m 18x1 mm | 245 | CC= -0.18m SSL | -0.18 m | 0 Pa | NN=-0.38 m | 00 | ins= 0.000000 mm | Edge= -0.18m SSL | Y=22.41 | CC= 3.48m FCL | Hallway | Dra.no: 1 | 5 | 00.03 | 0 | Storey: 2 | Heat flow | NNUK=-0.38 m | 0.000000 l/h | .000 | .0000 | 0.00 \X\B0C | Top= 3.47m FCL | CC= -0.18m FFB | 0.00 l/s | 0.00 l/s | 0.0 Pa | 0.00 m/s | X=30.32
Pipe | 00 Ground floor | ML-Copper pipes length 5 m 18x1 mm | 277.569 | CC= -0.20m SSL | -0.20 m | 0 Pa | NN=-0.40 m | 00 | ins= 0.000000 mm | Edge= -0.21m SSL | Y=22.10 | CC= 3.50m FCL | Hallway | Dra.no: 1 | 5 | 00.03 | 0 | Storey: 2 | Heat flow | NNUK=-0.41 m | 0.000000 l/h | .000 | .0000 | 0.00 \X\B0C | Top= 3.49m FCL | CC= -0.20m FFB | 0.00 l/s | 0.00 l/s | 0.0 Pa | 0.00 m/s | X=30.32
Pipe | 00 Ground floor | ML-Copper pipes length 5 m 18x1 mm | 7.5 | CC= 0.11m SSL | 0.11 m | 0 Pa | NN=-0.09 m | 00 | ins= 0.000000 mm | Edge= 0.10m SSL | Y=22.25 | CC= 3.19m FCL | Hallway | Dra.no: 1 | 6 | 00.03 | 0 | Storey: 2 | Heat return | NNUK=-0.09 m | 0.000000 l/h | .000 | .0000 | 0.00 \X\B0C | Top= 3.18m FCL | CC= 0.11m FFB | 0.00 l/s | 0.00 l/s | 0.0 Pa | 0.00 m/s | X=27.62
Pipe | 00 Ground floor | ML-Copper pipes length 5 m 18x1 mm | 113.5 | CC= 0.09m SSL | 0.09 m | 0 Pa | NN=-0.11 m | 00 | ins= 0.000000 mm | Edge= 0.08m SSL | Y=22.38 | CC= 3.21m FCL | Hallway | Dra.no: 1 | 6 | 00.03 | 0 | Storey: 2 | Heat return | NNUK=-0.12 m | 0.000000 l/h | .000 | .0000 | 0.00 \X\B0C | Top= 3.20m FCL | CC= 0.09m FFB | 0.00 l/s | 0.00 l/s | 0.0 Pa | 0.00 m/s | X=27.62
Pipe | 00 Ground floor | ML-Copper pipes length 5 m 18x1 mm | 145 | CC= -0.08m SSL | -0.08 m | 0 Pa | NN=-0.28 m | 00 | ins= 0.000000 mm | Edge= -0.08m SSL | Y=22.41 | CC= 3.38m FCL | Hallway | Dra.no: 1 | 6 | 00.03 | 0 | Storey: 2 | Heat return | NNUK=-0.28 m | 0.000000 l/h | .000 | .0000 | 0.00 \X\B0C | Top= 3.37m FCL | CC= -0.08m FFB | 0.00 l/s | 0.00 l/s | 0.0 Pa | 0.00 m/s | X=27.62
Pipe | 00 Ground floor | ML-Copper pipes length 5 m 18x1 mm | 393.587 | CC= -0.10m SSL | -0.10 m | 0 Pa | NN=-0.30 m | 00 | ins= 0.000000 mm | Edge= -0.11m SSL | Y=21.99 | CC= 3.40m FCL | Hallway | Dra.no: 1 | 6 | 00.03 | 0 | Storey: 2 | Heat return | NNUK=-0.31 m | 0.000000 l/h | .000 | .0000 | 0.00 \X\B0C | Top= 3.39m FCL | CC= -0.10m FFB | 0.00 l/s | 0.00 l/s | 0.0 Pa | 0.00 m/s | X=27.62
Pipe | 00 Ground floor | ML-Copper pipes length 5 m 18x1 mm | 7.5 | CC= 0.11m SSL | 0.11 m | 0 Pa | NN=-0.09 m | 00 | ins= 0.000000 mm | Edge= 0.10m SSL | Y=22.25 | CC= 3.19m FCL | Hallway | Dra.no: 1 | 5 | 00.03 | 0 | Storey: 2 | Heat flow | NNUK=-0.09 m | 0.000000 l/h | .000 | .0000 | 0.00 \X\B0C | Top= 3.18m FCL | CC= 0.11m FFB | 0.00 l/s | 0.00 l/s | 0.0 Pa | 0.00 m/s | X=27.57
Pipe | 00 Ground floor | ML-Copper pipes length 5 m 18x1 mm | 113.5 | CC= 0.09m SSL | 0.09 m | 0 Pa | NN=-0.11 m | 00 | ins= 0.000000 mm | Edge= 0.08m SSL | Y=22.38 | CC= 3.21m FCL | Hallway | Dra.no: 1 | 5 | 00.03 | 0 | Storey: 2 | Heat flow | NNUK=-0.12 m | 0.000000 l/h | .000 | .0000 | 0.00 \X\B0C | Top= 3.20m FCL | CC= 0.09m FFB | 0.00 l/s | 0.00 l/s | 0.0 Pa | 0.00 m/s | X=27.57
Pipe | 00 Ground floor | ML-Copper pipes length 5 m 18x1 mm | 245 | CC= -0.18m SSL | -0.18 m | 0 Pa | NN=-0.38 m | 00 | ins= 0.000000 mm | Edge= -0.18m SSL | Y=22.41 | CC= 3.48m FCL | Hallway | Dra.no: 1 | 5 | 00.03 | 0 | Storey: 2 | Heat flow | NNUK=-0.38 m | 0.000000 l/h | .000 | .0000 | 0.00 \X\B0C | Top= 3.47m FCL | CC= -0.18m FFB | 0.00 l/s | 0.00 l/s | 0.0 Pa | 0.00 m/s | X=27.57
Pipe | 00 Ground floor | ML-Copper pipes length 5 m 18x1 mm | 265.569 | CC= -0.20m SSL | -0.20 m | 0 Pa | NN=-0.40 m | 00 | ins= 0.000000 mm | Edge= -0.21m SSL | Y=22.12 | CC= 3.50m FCL | Hallway | Dra.no: 1 | 5 | 00.03 | 0 | Storey: 2 | Heat flow | NNUK=-0.41 m | 0.000000 l/h | .000 | .0000 | 0.00 \X\B0C | Top= 3.49m FCL | CC= -0.20m FFB | 0.00 l/s | 0.00 l/s | 0.0 Pa | 0.00 m/s | X=27.57
Pipe | 00 Ground floor | ML-Copper pipes length 5 m 18x1 mm | 7.5 | CC= 0.11m SSL | 0.11 m | 0 Pa | NN=-0.09 m | 00 | ins= 0.000000 mm | Edge= 0.10m SSL | Y=22.25 | CC= 3.19m FCL | Hallway | Dra.no: 1 | 6 | 00.03 | 0 | Storey: 2 | Heat return | NNUK=-0.09 m | 0.000000 l/h | .000 | .0000 | 0.00 \X\B0C | Top= 3.18m FCL | CC= 0.11m FFB | 0.00 l/s | 0.00 l/s | 0.0 Pa | 0.00 m/s | X=25.37
Pipe | 00 Ground floor | ML-Copper pipes length 5 m 18x1 mm | 113.5 | CC= 0.09m SSL | 0.09 m | 0 Pa | NN=-0.11 m | 00 | ins= 0.000000 mm | Edge= 0.08m SSL | Y=22.38 | CC= 3.21m FCL | Hallway | Dra.no: 1 | 6 | 00.03 | 0 | Storey: 2 | Heat return | NNUK=-0.12 m | 0.000000 l/h | .000 | .0000 | 0.00 \X\B0C | Top= 3.20m FCL | CC= 0.09m FFB | 0.00 l/s | 0.00 l/s | 0.0 Pa | 0.00 m/s | X=25.37
Pipe | 00 Ground floor | ML-Copper pipes length 5 m 18x1 mm | 145 | CC= -0.08m SSL | -0.08 m | 0 Pa | NN=-0.28 m | 00 | ins= 0.000000 mm | Edge= -0.08m SSL | Y=22.41 | CC= 3.38m FCL | Hallway | Dra.no: 1 | 6 | 00.03 | 0 | Storey: 2 | Heat return | NNUK=-0.28 m | 0.000000 l/h | .000 | .0000 | 0.00 \X\B0C | Top= 3.37m FCL | CC= -0.08m FFB | 0.00 l/s | 0.00 l/s | 0.0 Pa | 0.00 m/s | X=25.37
Pipe | 00 Ground floor | ML-Copper pipes length 5 m 18x1 mm | 393.587 | CC= -0.10m SSL | -0.10 m | 0 Pa | NN=-0.30 m | 00 | ins= 0.000000 mm | Edge= -0.11m SSL | Y=21.99 | CC= 3.40m FCL | Hallway | Dra.no: 1 | 6 | 00.03 | 0 | Storey: 2 | Heat return | NNUK=-0.31 m | 0.000000 l/h | .000 | .0000 | 0.00 \X\B0C | Top= 3.39m FCL | CC= -0.10m FFB | 0.00 l/s | 0.00 l/s | 0.0 Pa | 0.00 m/s | X=25.37
Pipe | 01 First floor | ML-Copper pipes length 5 m 18x1 mm | 245 | CC= -0.06m SSL | -0.18 m | 0 Pa | NN=3.12 m | 00 | ins= 0.000000 mm | Edge= -0.07m SSL | Y=22.41 | CC= 3.36m FCL | Office | Dra.no: 2 | 6 | 01.18 | 0 | Storey: 3 | Heat return | NNUK=3.12 m | 0.000000 l/h | .000 | .0000 | 0.00 \X\B0C | Top= 3.35m FCL | CC= -0.06m FFB | 0.00 l/s | 0.00 l/s | 0.0 Pa | 0.00 m/s | X=11.57
Pipe | 01 First floor | ML-Copper pipes length 5 m 18x1 mm | 67.5792 | CC= 0.21m SSL | 0.09 m | 0 Pa | NN=3.39 m | 00 | ins= 0.000000 mm | Edge= 0.20m SSL | Y=22.38 | CC= 3.09m FCL | Office | Dra.no: 2 | 6 | 01.18 | 0 | Storey: 3 | Heat return | NNUK=3.38 m | 0.000000 l/h | .000 | .0000 | 0.00 \X\B0C | Top= 3.08m FCL | CC= 0.21m FFB | 0.00 l/s | 0.00 l/s | 0.0 Pa | 0.00 m/s | X=11.57
Pipe | 01 First floor | ML-Copper pipes length 5 m 18x1 mm | 7.5 | CC= 0.23m SSL | 0.11 m | 0 Pa | NN=3.41 m | 00 | ins= 0.000000 mm | Edge= 0.22m SSL | Y=22.29 | CC= 3.07m FCL | Office | Dra.no: 2 | 6 | 01.18 | 0 | Storey: 3 | Heat return | NNUK=3.41 m | 0.000000 l/h | .000 | .0000 | 0.00 \X\B0C | Top= 3.06m FCL | CC= 0.23m FFB | 0.00 l/s | 0.00 l/s | 0.0 Pa | 0.00 m/s | X=11.57
Pipe | 01 First floor | ML-Copper pipes length 5 m 18x1 mm | 195.429 | CC= 0.02m SSL | -0.10 m | 0 Pa | NN=3.20 m | 00 | ins= 0.000000 mm | Edge= 0.01m SSL | Y=22.19 | CC= 3.28m FCL | Office | Dra.no: 2 | 5 | 01.19 | 0 | Storey: 3 | Heat flow | NNUK=3.19 m | 0.000000 l/h | .000 | .0000 | 0.00 \X\B0C | Top= 3.27m FCL | CC= 0.02m FFB | 0.00 l/s | 0.00 l/s | 0.0 Pa | 0.00 m/s | X=18.27
Pipe | 01 First floor | ML-Copper pipes length 5 m 18x1 mm | 145 | CC= 0.04m SSL | -0.08 m | 0 Pa | NN=3.22 m | 00 | ins= 0.000000 mm | Edge= 0.04m SSL | Y=22.41 | CC= 3.26m FCL | Office | Dra.no: 2 | 5 | 01.19 | 0 | Storey: 3 | Heat flow | NNUK=3.22 m | 0.000000 l/h | .000 | .0000 | 0.00 \X\B0C | Top= 3.25m FCL | CC= 0.04m FFB | 0.00 l/s | 0.00 l/s | 0.0 Pa | 0.00 m/s | X=18.27
Pipe | 01 First floor | ML-Copper pipes length 5 m 18x1 mm | 67.5792 | CC= 0.21m SSL | 0.09 m | 0 Pa | NN=3.39 m | 00 | ins= 0.000000 mm | Edge= 0.20m SSL | Y=22.38 | CC= 3.09m FCL | Office | Dra.no: 2 | 5 | 01.19 | 0 | Storey: 3 | Heat flow | NNUK=3.38 m | 0.000000 l/h | .000 | .0000 | 0.00 \X\B0C | Top= 3.08m FCL | CC= 0.21m FFB | 0.00 l/s | 0.00 l/s | 0.0 Pa | 0.00 m/s | X=18.27
Pipe | 01 First floor | ML-Copper pipes length 5 m 18x1 mm | 7.5 | CC= 0.23m SSL | 0.11 m | 0 Pa | NN=3.41 m | 00 | ins= 0.000000 mm | Edge= 0.22m SSL | Y=22.29 | CC= 3.07m FCL | Office | Dra.no: 2 | 5 | 01.19 | 0 | Storey: 3 | Heat flow | NNUK=3.41 m | 0.000000 l/h | .000 | .0000 | 0.00 \X\B0C | Top= 3.06m FCL | CC= 0.23m FFB | 0.00 l/s | 0.00 l/s | 0.0 Pa | 0.00 m/s | X=18.27
Pipe | 01 First floor | ML-Copper pipes length 5 m 18x1 mm | 309.915 | CC= -0.08m SSL | -0.20 m | 0 Pa | NN=3.10 m | 00 | ins= 0.000000 mm | Edge= -0.09m SSL | Y=22.07 | CC= 3.38m FCL | Office | Dra.no: 2 | 6 | 01.19 | 0 | Storey: 3 | Heat return | NNUK=3.09 m | 0.000000 l/h | .000 | .0000 | 0.00 \X\B0C | Top= 3.37m FCL | CC= -0.08m FFB | 0.00 l/s | 0.00 l/s | 0.0 Pa | 0.00 m/s | X=18.32
Pipe | 01 First floor | ML-Copper pipes length 5 m 18x1 mm | 245 | CC= -0.06m SSL | -0.18 m | 0 Pa | NN=3.12 m | 00 | ins= 0.000000 mm | Edge= -0.06m SSL | Y=22.41 | CC= 3.36m FCL | Office | Dra.no: 2 | 6 | 01.19 | 0 | Storey: 3 | Heat return | NNUK=3.12 m | 0.000000 l/h | .000 | .0000 | 0.00 \X\B0C | Top= 3.35m FCL | CC= -0.06m FFB | 0.00 l/s | 0.00 l/s | 0.0 Pa | 0.00 m/s | X=18.32
Pipe | 01 First floor | ML-Copper pipes length 5 m 18x1 mm | 67.5792 | CC= 0.21m SSL | 0.09 m | 0 Pa | NN=3.39 m | 00 | ins= 0.000000 mm | Edge= 0.20m SSL | Y=22.38 | CC= 3.09m FCL | Office | Dra.no: 2 | 6 | 01.19 | 0 | Storey: 3 | Heat return | NNUK=3.38 m | 0.000000 l/h | .000 | .0000 | 0.00 \X\B0C | Top= 3.08m FCL | CC= 0.21m FFB | 0.00 l/s | 0.00 l/s | 0.0 Pa | 0.00 m/s | X=18.32
Pipe | 01 First floor | ML-Copper pipes length 5 m 18x1 mm | 65.9134 | CC= -0.04m SSL | 0.09 m | 0 Pa | NN=3.39 m | 00 | ins= 0.000000 mm | Edge= -0.05m SSL | Y=14.42 | CC= 3.34m FCL | Office | Dra.no: 2 | 5 | 01.17 | 0 | Storey: 3 | Heat flow | NNUK=3.38 m | 0.000000 l/h | .000 | .0000 | 0.00 \X\B0C | Top= 3.33m FCL | CC= -0.04m FFB | 0.00 l/s | 0.00 l/s | 0.0 Pa | 0.00 m/s | X=5.27
Pipe | 01 First floor | ML-Copper pipes length 5 m 18x1 mm | 7.5 | CC= -0.02m SSL | 0.11 m | 0 Pa | NN=3.41 m | 00 | ins= 0.000000 mm | Edge= -0.03m SSL | Y=14.42 | CC= 3.32m FCL | Office | Dra.no: 2 | 5 | 01.17 | 0 | Storey: 3 | Heat flow | NNUK=3.41 m | 0.000000 l/h | .000 | .0000 | 0.00 \X\B0C | Top= 3.31m FCL | CC= -0.02m FFB | 0.00 l/s | 0.00 l/s | 0.0 Pa | 0.00 m/s | X=5.36
Pipe | 01 First floor | ML-Copper pipes length 5 m 18x1 mm | 373.309 | CC= -0.33m SSL | -0.20 m | 0 Pa | NN=3.10 m | 00 | ins= 0.000000 mm | Edge= -0.34m SSL | Y=14.47 | CC= 3.63m FCL | Office | Dra.no: 2 | 6 | 01.17 | 0 | Storey: 3 | Heat return | NNUK=3.09 m | 0.000000 l/h | .000 | .0000 | 0.00 \X\B0C | Top= 3.62m FCL | CC= -0.33m FFB | 0.00 l/s | 0.00 l/s | 0.0 Pa | 0.00 m/s | X=5.64
Pipe | 01 First floor | ML-Copper pipes length 5 m 18x1 mm | 245 | CC= -0.31m SSL | -0.18 m | 0 Pa | NN=3.12 m | 00 | ins= 0.000000 mm | Edge= -0.32m SSL | Y=14.47 | CC= 3.61m FCL | Office | Dra.no: 2 | 6 | 01.17 | 0 | Storey: 3 | Heat return | NNUK=3.12 m | 0.000000 l/h | .000 | .0000 | 0.00 \X\B0C | Top= 3.60m FCL | CC= -0.31m FFB | 0.00 l/s | 0.00 l/s | 0.0 Pa | 0.00 m/s | X=5.25
Pipe | 01 First floor | ML-Copper pipes length 5 m 18x1 mm | 65.9134 | CC= -0.04m SSL | 0.09 m | 0 Pa | NN=3.39 m | 00 | ins= 0.000000 mm | Edge= -0.05m SSL | Y=14.47 | CC= 3.34m FCL | Office | Dra.no: 2 | 6 | 01.17 | 0 | Storey: 3 | Heat return | NNUK=3.38 m | 0.000000 l/h | .000 | .0000 | 0.00 \X\B0C | Top= 3.33m FCL | CC= -0.04m FFB | 0.00 l/s | 0.00 l/s | 0.0 Pa | 0.00 m/s | X=5.27
Pipe | 01 First floor | ML-Copper pipes length 5 m 18x1 mm | 7.5 | CC= -0.02m SSL | 0.11 m | 0 Pa | NN=3.41 m | 00 | ins= 0.000000 mm | Edge= -0.03m SSL | Y=14.47 | CC= 3.32m FCL | Office | Dra.no: 2 | 6 | 01.17 | 0 | Storey: 3 | Heat return | NNUK=3.41 m | 0.000000 l/h | .000 | .0000 | 0.00 \X\B0C | Top= 3.31m FCL | CC= -0.02m FFB | 0.00 l/s | 0.00 l/s | 0.0 Pa | 0.00 m/s | X=5.36
Pipe | 01 First floor | ML-Copper pipes length 5 m 18x1 mm | 195.429 | CC= 0.02m SSL | -0.10 m | 0 Pa | NN=3.20 m | 00 | ins= 0.000000 mm | Edge= 0.01m SSL | Y=22.19 | CC= 3.28m FCL | Office | Dra.no: 2 | 5 | 01.18 | 0 | Storey: 3 | Heat flow | NNUK=3.19 m | 0.000000 l/h | .000 | .0000 | 0.00 \X\B0C | Top= 3.27m FCL | CC= 0.02m FFB | 0.00 l/s | 0.00 l/s | 0.0 Pa | 0.00 m/s | X=11.52
Pipe | 01 First floor | ML-Copper pipes length 5 m 18x1 mm | 145 | CC= 0.04m SSL | -0.08 m | 0 Pa | NN=3.22 m | 00 | ins= 0.000000 mm | Edge= 0.03m SSL | Y=22.41 | CC= 3.26m FCL | Office | Dra.no: 2 | 5 | 01.18 | 0 | Storey: 3 | Heat flow | NNUK=3.22 m | 0.000000 l/h | .000 | .0000 | 0.00 \X\B0C | Top= 3.25m FCL | CC= 0.04m FFB | 0.00 l/s | 0.00 l/s | 0.0 Pa | 0.00 m/s | X=11.52
Pipe | 01 First floor | ML-Copper pipes length 5 m 18x1 mm | 67.5792 | CC= 0.21m SSL | 0.09 m | 0 Pa | NN=3.39 m | 00 | ins= 0.000000 mm | Edge= 0.20m SSL | Y=22.38 | CC= 3.09m FCL | Office | Dra.no: 2 | 5 | 01.18 | 0 | Storey: 3 | Heat flow | NNUK=3.38 m | 0.000000 l/h | .000 | .0000 | 0.00 \X\B0C | Top= 3.08m FCL | CC= 0.21m FFB | 0.00 l/s | 0.00 l/s | 0.0 Pa | 0.00 m/s | X=11.52
Pipe | 01 First floor | ML-Copper pipes length 5 m 18x1 mm | 7.5 | CC= 0.23m SSL | 0.11 m | 0 Pa | NN=3.41 m | 00 | ins= 0.000000 mm | Edge= 0.22m SSL | Y=22.29 | CC= 3.07m FCL | Office | Dra.no: 2 | 5 | 01.18 | 0 | Storey: 3 | Heat flow | NNUK=3.41 m | 0.000000 l/h | .000 | .0000 | 0.00 \X\B0C | Top= 3.06m FCL | CC= 0.23m FFB | 0.00 l/s | 0.00 l/s | 0.0 Pa | 0.00 m/s | X=11.52
Pipe | 01 First floor | ML-Copper pipes length 5 m 18x1 mm | 309.915 | CC= -0.08m SSL | -0.20 m | 0 Pa | NN=3.10 m | 00 | ins= 0.000000 mm | Edge= -0.09m SSL | Y=22.07 | CC= 3.38m FCL | Office | Dra.no: 2 | 6 | 01.18 | 0 | Storey: 3 | Heat return | NNUK=3.09 m | 0.000000 l/h | .000 | .0000 | 0.00 \X\B0C | Top= 3.37m FCL | CC= -0.08m FFB | 0.00 l/s | 0.00 l/s | 0.0 Pa | 0.00 m/s | X=11.57
Pipe | 01 First floor | ML-Copper pipes length 5 m 18x1 mm | 7.5 | CC= 0.23m SSL | 0.11 m | 0 Pa | NN=3.41 m | 00 | ins= 0.000000 mm | Edge= 0.22m SSL | Y=22.29 | CC= 3.07m FCL | Office | Dra.no: 2 | 6 | 01.19 | 0 | Storey: 3 | Heat return | NNUK=3.41 m | 0.000000 l/h | .000 | .0000 | 0.00 \X\B0C | Top= 3.06m FCL | CC= 0.23m FFB | 0.00 l/s | 0.00 l/s | 0.0 Pa | 0.00 m/s | X=18.32
Pipe | 01 First floor | ML-Copper pipes length 5 m 18x1 mm | 195.429 | CC= 0.02m SSL | -0.10 m | 0 Pa | NN=3.20 m | 00 | ins= 0.000000 mm | Edge= 0.01m SSL | Y=22.19 | CC= 3.28m FCL | Office | Dra.no: 2 | 5 | 01.20 | 0 | Storey: 3 | Heat flow | NNUK=3.19 m | 0.000000 l/h | .000 | .0000 | 0.00 \X\B0C | Top= 3.27m FCL | CC= 0.02m FFB | 0.00 l/s | 0.00 l/s | 0.0 Pa | 0.00 m/s | X=16.02
Pipe | 01 First floor | ML-Copper pipes length 5 m 18x1 mm | 145 | CC= 0.04m SSL | -0.08 m | 0 Pa | NN=3.22 m | 00 | ins= 0.000000 mm | Edge= 0.03m SSL | Y=22.41 | CC= 3.26m FCL | Office | Dra.no: 2 | 5 | 01.20 | 0 | Storey: 3 | Heat flow | NNUK=3.22 m | 0.000000 l/h | .000 | .0000 | 0.00 \X\B0C | Top= 3.25m FCL | CC= 0.04m FFB | 0.00 l/s | 0.00 l/s | 0.0 Pa | 0.00 m/s | X=16.02
Pipe | 01 First floor | ML-Copper pipes length 5 m 18x1 mm | 67.5792 | CC= 0.21m SSL | 0.09 m | 0 Pa | NN=3.39 m | 00 | ins= 0.000000 mm | Edge= 0.20m SSL | Y=22.38 | CC= 3.09m FCL | Office | Dra.no: 2 | 5 | 01.20 | 0 | Storey: 3 | Heat flow | NNUK=3.38 m | 0.000000 l/h | .000 | .0000 | 0.00 \X\B0C | Top= 3.08m FCL | CC= 0.21m FFB | 0.00 l/s | 0.00 l/s | 0.0 Pa | 0.00 m/s | X=16.02
Pipe | 01 First floor | ML-Copper pipes length 5 m 18x1 mm | 7.5 | CC= 0.23m SSL | 0.11 m | 0 Pa | NN=3.41 m | 00 | ins= 0.000000 mm | Edge= 0.22m SSL | Y=22.29 | CC= 3.07m FCL | Office | Dra.no: 2 | 5 | 01.20 | 0 | Storey: 3 | Heat flow | NNUK=3.41 m | 0.000000 l/h | .000 | .0000 | 0.00 \X\B0C | Top= 3.06m FCL | CC= 0.23m FFB | 0.00 l/s | 0.00 l/s | 0.0 Pa | 0.00 m/s | X=16.02
Pipe | 01 First floor | ML-Copper pipes length 5 m 18x1 mm | 309.915 | CC= -0.08m SSL | -0.20 m | 0 Pa | NN=3.10 m | 00 | ins= 0.000000 mm | Edge= -0.09m SSL | Y=22.07 | CC= 3.38m FCL | Office | Dra.no: 2 | 6 | 01.20 | 0 | Storey: 3 | Heat return | NNUK=3.09 m | 0.000000 l/h | .000 | .0000 | 0.00 \X\B0C | Top= 3.37m FCL | CC= -0.08m FFB | 0.00 l/s | 0.00 l/s | 0.0 Pa | 0.00 m/s | X=16.07
Pipe | 01 First floor | ML-Copper pipes length 5 m 18x1 mm | 245 | CC= -0.06m SSL | -0.18 m | 0 Pa | NN=3.12 m | 00 | ins= 0.000000 mm | Edge= -0.06m SSL | Y=22.41 | CC= 3.36m FCL | Office | Dra.no: 2 | 6 | 01.20 | 0 | Storey: 3 | Heat return | NNUK=3.12 m | 0.000000 l/h | .000 | .0000 | 0.00 \X\B0C | Top= 3.35m FCL | CC= -0.06m FFB | 0.00 l/s | 0.00 l/s | 0.0 Pa | 0.00 m/s | X=16.07
Pipe | 01 First floor | ML-Copper pipes length 5 m 18x1 mm | 67.5792 | CC= 0.21m SSL | 0.09 m | 0 Pa | NN=3.39 m | 00 | ins= 0.000000 mm | Edge= 0.20m SSL | Y=22.38 | CC= 3.09m FCL | Office | Dra.no: 2 | 6 | 01.20 | 0 | Storey: 3 | Heat return | NNUK=3.38 m | 0.000000 l/h | .000 | .0000 | 0.00 \X\B0C | Top= 3.08m FCL | CC= 0.21m FFB | 0.00 l/s | 0.00 l/s | 0.0 Pa | 0.00 m/s | X=16.07
Pipe | 01 First floor | ML-Copper pipes length 5 m 18x1 mm | 7.5 | CC= 0.23m SSL | 0.11 m | 0 Pa | NN=3.41 m | 00 | ins= 0.000000 mm | Edge= 0.22m SSL | Y=22.29 | CC= 3.07m FCL | Office | Dra.no: 2 | 6 | 01.20 | 0 | Storey: 3 | Heat return | NNUK=3.41 m | 0.000000 l/h | .000 | .0000 | 0.00 \X\B0C | Top= 3.06m FCL | CC= 0.23m FFB | 0.00 l/s | 0.00 l/s | 0.0 Pa | 0.00 m/s | X=16.07
Pipe | 01 First floor | ML-Copper pipes length 5 m 18x1 mm | 195.429 | CC= -0.23m SSL | -0.10 m | 0 Pa | NN=3.20 m | 00 | ins= 0.000000 mm | Edge= -0.24m SSL | Y=22.19 | CC= 3.53m FCL | Hallway | Dra.no: 2 | 5 | 01.02 | 0 | Storey: 3 | Heat flow | NNUK=3.19 m | 0.000000 l/h | .000 | .0000 | 0.00 \X\B0C | Top= 3.52m FCL | CC= -0.23m FFB | 0.00 l/s | 0.00 l/s | 0.0 Pa | 0.00 m/s | X=27.52
Pipe | 01 First floor | ML-Copper pipes length 5 m 18x1 mm | 145 | CC= -0.21m SSL | -0.08 m | 0 Pa | NN=3.22 m | 00 | ins= 0.000000 mm | Edge= -0.21m SSL | Y=22.40 | CC= 3.51m FCL | Hallway | Dra.no: 2 | 5 | 01.02 | 0 | Storey: 3 | Heat flow | NNUK=3.22 m | 0.000000 l/h | .000 | .0000 | 0.00 \X\B0C | Top= 3.50m FCL | CC= -0.21m FFB | 0.00 l/s | 0.00 l/s | 0.0 Pa | 0.00 m/s | X=27.52
Pipe | 01 First floor | ML-Copper pipes length 5 m 18x1 mm | 67.5792 | CC= -0.04m SSL | 0.09 m | 0 Pa | NN=3.39 m | 00 | ins= 0.000000 mm | Edge= -0.05m SSL | Y=22.38 | CC= 3.34m FCL | Hallway | Dra.no: 2 | 5 | 01.02 | 0 | Storey: 3 | Heat flow | NNUK=3.38 m | 0.000000 l/h | .000 | .0000 | 0.00 \X\B0C | Top= 3.33m FCL | CC= -0.04m FFB | 0.00 l/s | 0.00 l/s | 0.0 Pa | 0.00 m/s | X=27.52
Pipe | 01 First floor | ML-Copper pipes length 5 m 18x1 mm | 7.5 | CC= -0.02m SSL | 0.11 m | 0 Pa | NN=3.41 m | 00 | ins= 0.000000 mm | Edge= -0.03m SSL | Y=22.29 | CC= 3.32m FCL | Hallway | Dra.no: 2 | 5 | 01.02 | 0 | Storey: 3 | Heat flow | NNUK=3.41 m | 0.000000 l/h | .000 | .0000 | 0.00 \X\B0C | Top= 3.31m FCL | CC= -0.02m FFB | 0.00 l/s | 0.00 l/s | 0.0 Pa | 0.00 m/s | X=27.52
Pipe | 01 First floor | ML-Copper pipes length 5 m 18x1 mm | 309.915 | CC= -0.33m SSL | -0.20 m | 0 Pa | NN=3.10 m | 00 | ins= 0.000000 mm | Edge= -0.34m SSL | Y=22.07 | CC= 3.63m FCL | Hallway | Dra.no: 2 | 6 | 01.02 | 0 | Storey: 3 | Heat return | NNUK=3.09 m | 0.000000 l/h | .000 | .0000 | 0.00 \X\B0C | Top= 3.62m FCL | CC= -0.33m FFB | 0.00 l/s | 0.00 l/s | 0.0 Pa | 0.00 m/s | X=27.57
Pipe | 01 First floor | ML-Copper pipes length 5 m 18x1 mm | 245 | CC= -0.31m SSL | -0.18 m | 0 Pa | NN=3.12 m | 00 | ins= 0.000000 mm | Edge= -0.31m SSL | Y=22.40 | CC= 3.61m FCL | Hallway | Dra.no: 2 | 6 | 01.02 | 0 | Storey: 3 | Heat return | NNUK=3.12 m | 0.000000 l/h | .000 | .0000 | 0.00 \X\B0C | Top= 3.60m FCL | CC= -0.31m FFB | 0.00 l/s | 0.00 l/s | 0.0 Pa | 0.00 m/s | X=27.57
Pipe | 01 First floor | ML-Copper pipes length 5 m 18x1 mm | 67.5792 | CC= -0.04m SSL | 0.09 m | 0 Pa | NN=3.39 m | 00 | ins= 0.000000 mm | Edge= -0.05m SSL | Y=22.38 | CC= 3.34m FCL | Hallway | Dra.no: 2 | 6 | 01.02 | 0 | Storey: 3 | Heat return | NNUK=3.38 m | 0.000000 l/h | .000 | .0000 | 0.00 \X\B0C | Top= 3.33m FCL | CC= -0.04m FFB | 0.00 l/s | 0.00 l/s | 0.0 Pa | 0.00 m/s | X=27.57
Pipe | 01 First floor | ML-Copper pipes length 5 m 18x1 mm | 7.5 | CC= -0.02m SSL | 0.11 m | 0 Pa | NN=3.41 m | 00 | ins= 0.000000 mm | Edge= -0.03m SSL | Y=22.29 | CC= 3.32m FCL | Hallway | Dra.no: 2 | 6 | 01.02 | 0 | Storey: 3 | Heat return | NNUK=3.41 m | 0.000000 l/h | .000 | .0000 | 0.00 \X\B0C | Top= 3.31m FCL | CC= -0.02m FFB | 0.00 l/s | 0.00 l/s | 0.0 Pa | 0.00 m/s | X=27.57
Pipe | 01 First floor | ML-Copper pipes length 5 m 18x1 mm | 195.429 | CC= -0.23m SSL | -0.10 m | 0 Pa | NN=3.20 m | 00 | ins= 0.000000 mm | Edge= -0.24m SSL | Y=22.19 | CC= 3.53m FCL | Hallway | Dra.no: 2 | 5 | 01.02 | 0 | Storey: 3 | Heat flow | NNUK=3.19 m | 0.000000 l/h | .000 | .0000 | 0.00 \X\B0C | Top= 3.52m FCL | CC= -0.23m FFB | 0.00 l/s | 0.00 l/s | 0.0 Pa | 0.00 m/s | X=25.27
Pipe | 01 First floor | ML-Copper pipes length 5 m 18x1 mm | 67.5792 | CC= -0.04m SSL | 0.09 m | 0 Pa | NN=3.39 m | 00 | ins= 0.000000 mm | Edge= -0.05m SSL | Y=22.38 | CC= 3.34m FCL | Staircase | Dra.no: 2 | 6 | 01.05 | 0 | Storey: 3 | Heat return | NNUK=3.38 m | 0.000000 l/h | .000 | .0000 | 0.00 \X\B0C | Top= 3.33m FCL | CC= -0.04m FFB | 0.00 l/s | 0.00 l/s | 0.0 Pa | 0.00 m/s | X=7.37
Pipe | 01 First floor | ML-Copper pipes length 5 m 18x1 mm | 7.5 | CC= -0.02m SSL | 0.11 m | 0 Pa | NN=3.41 m | 00 | ins= 0.000000 mm | Edge= -0.03m SSL | Y=22.29 | CC= 3.32m FCL | Staircase | Dra.no: 2 | 6 | 01.05 | 0 | Storey: 3 | Heat return | NNUK=3.41 m | 0.000000 l/h | .000 | .0000 | 0.00 \X\B0C | Top= 3.31m FCL | CC= -0.02m FFB | 0.00 l/s | 0.00 l/s | 0.0 Pa | 0.00 m/s | X=7.37
Pipe | 01 First floor | ML-Copper pipes length 5 m 18x1 mm | 195.429 | CC= 0.02m SSL | -0.10 m | 0 Pa | NN=3.20 m | 00 | ins= 0.000000 mm | Edge= 0.01m SSL | Y=22.19 | CC= 3.28m FCL | Storage | Dra.no: 2 | 5 | 01.13 | 0 | Storey: 3 | Heat flow | NNUK=3.19 m | 0.000000 l/h | .000 | .0000 | 0.00 \X\B0C | Top= 3.27m FCL | CC= 0.02m FFB | 0.00 l/s | 0.00 l/s | 0.0 Pa | 0.00 m/s | X=22.82
Pipe | 01 First floor | ML-Copper pipes length 5 m 18x1 mm | 145 | CC= 0.04m SSL | -0.08 m | 0 Pa | NN=3.22 m | 00 | ins= 0.000000 mm | Edge= 0.04m SSL | Y=22.41 | CC= 3.26m FCL | Storage | Dra.no: 2 | 5 | 01.13 | 0 | Storey: 3 | Heat flow | NNUK=3.22 m | 0.000000 l/h | .000 | .0000 | 0.00 \X\B0C | Top= 3.25m FCL | CC= 0.04m FFB | 0.00 l/s | 0.00 l/s | 0.0 Pa | 0.00 m/s | X=22.82
Pipe | 01 First floor | ML-Copper pipes length 5 m 18x1 mm | 65.9134 | CC= 0.21m SSL | 0.09 m | 0 Pa | NN=3.39 m | 00 | ins= 0.000000 mm | Edge= 0.20m SSL | Y=22.38 | CC= 3.09m FCL | Storage | Dra.no: 2 | 5 | 01.13 | 0 | Storey: 3 | Heat flow | NNUK=3.38 m | 0.000000 l/h | .000 | .0000 | 0.00 \X\B0C | Top= 3.08m FCL | CC= 0.21m FFB | 0.00 l/s | 0.00 l/s | 0.0 Pa | 0.00 m/s | X=22.82
Pipe | 01 First floor | ML-Copper pipes length 5 m 18x1 mm | 7.5 | CC= 0.23m SSL | 0.11 m | 0 Pa | NN=3.41 m | 00 | ins= 0.000000 mm | Edge= 0.22m SSL | Y=22.29 | CC= 3.07m FCL | Storage | Dra.no: 2 | 5 | 01.13 | 0 | Storey: 3 | Heat flow | NNUK=3.41 m | 0.000000 l/h | .000 | .0000 | 0.00 \X\B0C | Top= 3.06m FCL | CC= 0.23m FFB | 0.00 l/s | 0.00 l/s | 0.0 Pa | 0.00 m/s | X=22.82
Pipe | 01 First floor | ML-Copper pipes length 5 m 18x1 mm | 309.915 | CC= -0.08m SSL | -0.20 m | 0 Pa | NN=3.10 m | 00 | ins= 0.000000 mm | Edge= -0.09m SSL | Y=22.07 | CC= 3.38m FCL | Storage | Dra.no: 2 | 6 | 01.13 | 0 | Storey: 3 | Heat return | NNUK=3.09 m | 0.000000 l/h | .000 | .0000 | 0.00 \X\B0C | Top= 3.37m FCL | CC= -0.08m FFB | 0.00 l/s | 0.00 l/s | 0.0 Pa | 0.00 m/s | X=22.87
Pipe | 01 First floor | ML-Copper pipes length 5 m 18x1 mm | 245 | CC= -0.06m SSL | -0.18 m | 0 Pa | NN=3.12 m | 00 | ins= 0.000000 mm | Edge= -0.06m SSL | Y=22.41 | CC= 3.36m FCL | Storage | Dra.no: 2 | 6 | 01.13 | 0 | Storey: 3 | Heat return | NNUK=3.12 m | 0.000000 l/h | .000 | .0000 | 0.00 \X\B0C | Top= 3.35m FCL | CC= -0.06m FFB | 0.00 l/s | 0.00 l/s | 0.0 Pa | 0.00 m/s | X=22.87
Pipe | 01 First floor | ML-Copper pipes length 5 m 18x1 mm | 65.9134 | CC= 0.21m SSL | 0.09 m | 0 Pa | NN=3.39 m | 00 | ins= 0.000000 mm | Edge= 0.20m SSL | Y=22.38 | CC= 3.09m FCL | Storage | Dra.no: 2 | 6 | 01.13 | 0 | Storey: 3 | Heat return | NNUK=3.38 m | 0.000000 l/h | .000 | .0000 | 0.00 \X\B0C | Top= 3.08m FCL | CC= 0.21m FFB | 0.00 l/s | 0.00 l/s | 0.0 Pa | 0.00 m/s | X=22.87
Pipe | 01 First floor | ML-Copper pipes length 5 m 18x1 mm | 7.5 | CC= 0.23m SSL | 0.11 m | 0 Pa | NN=3.41 m | 00 | ins= 0.000000 mm | Edge= 0.22m SSL | Y=22.29 | CC= 3.07m FCL | Storage | Dra.no: 2 | 6 | 01.13 | 0 | Storey: 3 | Heat return | NNUK=3.41 m | 0.000000 l/h | .000 | .0000 | 0.00 \X\B0C | Top= 3.06m FCL | CC= 0.23m FFB | 0.00 l/s | 0.00 l/s | 0.0 Pa | 0.00 m/s | X=22.87
Pipe | 01 First floor | ML-Copper pipes length 5 m 18x1 mm | 233.821 | CC= -0.23m SSL | -0.10 m | 0 Pa | NN=3.20 m | 00 | ins= 0.000000 mm | Edge= -0.24m SSL | Y=14.42 | CC= 3.53m FCL | Office | Dra.no: 2 | 5 | 01.17 | 0 | Storey: 3 | Heat flow | NNUK=3.19 m | 0.000000 l/h | .000 | .0000 | 0.00 \X\B0C | Top= 3.52m FCL | CC= -0.23m FFB | 0.00 l/s | 0.00 l/s | 0.0 Pa | 0.00 m/s | X=5.50
Pipe | 01 First floor | ML-Copper pipes length 5 m 18x1 mm | 145 | CC= -0.21m SSL | -0.08 m | 0 Pa | NN=3.22 m | 00 | ins= 0.000000 mm | Edge= -0.22m SSL | Y=14.42 | CC= 3.51m FCL | Office | Dra.no: 2 | 5 | 01.17 | 0 | Storey: 3 | Heat flow | NNUK=3.22 m | 0.000000 l/h | .000 | .0000 | 0.00 \X\B0C | Top= 3.50m FCL | CC= -0.21m FFB | 0.00 l/s | 0.00 l/s | 0.0 Pa | 0.00 m/s | X=5.25
Pipe | 01 First floor | ML-Copper pipes length 5 m 18x1 mm | 145 | CC= -0.21m SSL | -0.08 m | 0 Pa | NN=3.22 m | 00 | ins= 0.000000 mm | Edge= -0.21m SSL | Y=22.40 | CC= 3.51m FCL | Hallway | Dra.no: 2 | 5 | 01.02 | 0 | Storey: 3 | Heat flow | NNUK=3.22 m | 0.000000 l/h | .000 | .0000 | 0.00 \X\B0C | Top= 3.50m FCL | CC= -0.21m FFB | 0.00 l/s | 0.00 l/s | 0.0 Pa | 0.00 m/s | X=25.27
Pipe | 01 First floor | ML-Copper pipes length 5 m 18x1 mm | 67.5792 | CC= -0.04m SSL | 0.09 m | 0 Pa | NN=3.39 m | 00 | ins= 0.000000 mm | Edge= -0.05m SSL | Y=22.38 | CC= 3.34m FCL | Hallway | Dra.no: 2 | 5 | 01.02 | 0 | Storey: 3 | Heat flow | NNUK=3.38 m | 0.000000 l/h | .000 | .0000 | 0.00 \X\B0C | Top= 3.33m FCL | CC= -0.04m FFB | 0.00 l/s | 0.00 l/s | 0.0 Pa | 0.00 m/s | X=25.27
Pipe | 01 First floor | ML-Copper pipes length 5 m 18x1 mm | 7.5 | CC= -0.02m SSL | 0.11 m | 0 Pa | NN=3.41 m | 00 | ins= 0.000000 mm | Edge= -0.03m SSL | Y=22.29 | CC= 3.32m FCL | Hallway | Dra.no: 2 | 5 | 01.02 | 0 | Storey: 3 | Heat flow | NNUK=3.41 m | 0.000000 l/h | .000 | .0000 | 0.00 \X\B0C | Top= 3.31m FCL | CC= -0.02m FFB | 0.00 l/s | 0.00 l/s | 0.0 Pa | 0.00 m/s | X=25.27
Pipe | 01 First floor | ML-Copper pipes length 5 m 18x1 mm | 309.915 | CC= -0.33m SSL | -0.20 m | 0 Pa | NN=3.10 m | 00 | ins= 0.000000 mm | Edge= -0.34m SSL | Y=22.07 | CC= 3.63m FCL | Hallway | Dra.no: 2 | 6 | 01.02 | 0 | Storey: 3 | Heat return | NNUK=3.09 m | 0.000000 l/h | .000 | .0000 | 0.00 \X\B0C | Top= 3.62m FCL | CC= -0.33m FFB | 0.00 l/s | 0.00 l/s | 0.0 Pa | 0.00 m/s | X=25.32
Pipe | 01 First floor | ML-Copper pipes length 5 m 18x1 mm | 245 | CC= -0.31m SSL | -0.18 m | 0 Pa | NN=3.12 m | 00 | ins= 0.000000 mm | Edge= -0.31m SSL | Y=22.40 | CC= 3.61m FCL | Hallway | Dra.no: 2 | 6 | 01.02 | 0 | Storey: 3 | Heat return | NNUK=3.12 m | 0.000000 l/h | .000 | .0000 | 0.00 \X\B0C | Top= 3.60m FCL | CC= -0.31m FFB | 0.00 l/s | 0.00 l/s | 0.0 Pa | 0.00 m/s | X=25.32
Pipe | 01 First floor | ML-Copper pipes length 5 m 18x1 mm | 67.5792 | CC= -0.04m SSL | 0.09 m | 0 Pa | NN=3.39 m | 00 | ins= 0.000000 mm | Edge= -0.05m SSL | Y=22.38 | CC= 3.34m FCL | Hallway | Dra.no: 2 | 6 | 01.02 | 0 | Storey: 3 | Heat return | NNUK=3.38 m | 0.000000 l/h | .000 | .0000 | 0.00 \X\B0C | Top= 3.33m FCL | CC= -0.04m FFB | 0.00 l/s | 0.00 l/s | 0.0 Pa | 0.00 m/s | X=25.32
Pipe | 01 First floor | ML-Copper pipes length 5 m 18x1 mm | 7.5 | CC= -0.02m SSL | 0.11 m | 0 Pa | NN=3.41 m | 00 | ins= 0.000000 mm | Edge= -0.03m SSL | Y=22.29 | CC= 3.32m FCL | Hallway | Dra.no: 2 | 6 | 01.02 | 0 | Storey: 3 | Heat return | NNUK=3.41 m | 0.000000 l/h | .000 | .0000 | 0.00 \X\B0C | Top= 3.31m FCL | CC= -0.02m FFB | 0.00 l/s | 0.00 l/s | 0.0 Pa | 0.00 m/s | X=25.32
Pipe | 01 First floor | ML-Copper pipes length 5 m 18x1 mm | 195.429 | CC= -0.23m SSL | -0.10 m | 0 Pa | NN=3.20 m | 00 | ins= 0.000000 mm | Edge= -0.24m SSL | Y=22.19 | CC= 3.53m FCL | Staircase | Dra.no: 2 | 5 | 01.05 | 0 | Storey: 3 | Heat flow | NNUK=3.19 m | 0.000000 l/h | .000 | .0000 | 0.00 \X\B0C | Top= 3.52m FCL | CC= -0.23m FFB | 0.00 l/s | 0.00 l/s | 0.0 Pa | 0.00 m/s | X=7.32
Pipe | 01 First floor | ML-Copper pipes length 5 m 18x1 mm | 7.5 | CC= -0.02m SSL | 0.11 m | 0 Pa | NN=3.41 m | 00 | ins= 0.000000 mm | Edge= -0.03m SSL | Y=22.29 | CC= 3.32m FCL | Staircase | Dra.no: 2 | 5 | 01.05 | 0 | Storey: 3 | Heat flow | NNUK=3.41 m | 0.000000 l/h | .000 | .0000 | 0.00 \X\B0C | Top= 3.31m FCL | CC= -0.02m FFB | 0.00 l/s | 0.00 l/s | 0.0 Pa | 0.00 m/s | X=7.32
Pipe | 01 First floor | ML-Copper pipes length 5 m 18x1 mm | 309.915 | CC= -0.33m SSL | -0.20 m | 0 Pa | NN=3.10 m | 00 | ins= 0.000000 mm | Edge= -0.34m SSL | Y=22.07 | CC= 3.63m FCL | Staircase | Dra.no: 2 | 6 | 01.05 | 0 | Storey: 3 | Heat return | NNUK=3.09 m | 0.000000 l/h | .000 | .0000 | 0.00 \X\B0C | Top= 3.62m FCL | CC= -0.33m FFB | 0.00 l/s | 0.00 l/s | 0.0 Pa | 0.00 m/s | X=7.37
Pipe | 01 First floor | ML-Copper pipes length 5 m 18x1 mm | 145 | CC= -0.21m SSL | -0.08 m | 0 Pa | NN=3.22 m | 00 | ins= 0.000000 mm | Edge= -0.22m SSL | Y=22.41 | CC= 3.51m FCL | Staircase | Dra.no: 2 | 5 | 01.05 | 0 | Storey: 3 | Heat flow | NNUK=3.22 m | 0.000000 l/h | .000 | .0000 | 0.00 \X\B0C | Top= 3.50m FCL | CC= -0.21m FFB | 0.00 l/s | 0.00 l/s | 0.0 Pa | 0.00 m/s | X=7.32
Pipe | 01 First floor | ML-Copper pipes length 5 m 18x1 mm | 67.5792 | CC= -0.04m SSL | 0.09 m | 0 Pa | NN=3.39 m | 00 | ins= 0.000000 mm | Edge= -0.05m SSL | Y=22.38 | CC= 3.34m FCL | Staircase | Dra.no: 2 | 5 | 01.05 | 0 | Storey: 3 | Heat flow | NNUK=3.38 m | 0.000000 l/h | .000 | .0000 | 0.00 \X\B0C | Top= 3.33m FCL | CC= -0.04m FFB | 0.00 l/s | 0.00 l/s | 0.0 Pa | 0.00 m/s | X=7.32
Pipe | 01 First floor | ML-Copper pipes length 5 m 18x1 mm | 245 | CC= -0.31m SSL | -0.18 m | 0 Pa | NN=3.12 m | 00 | ins= 0.000000 mm | Edge= -0.32m SSL | Y=22.41 | CC= 3.61m FCL | Staircase | Dra.no: 2 | 6 | 01.05 | 0 | Storey: 3 | Heat return | NNUK=3.12 m | 0.000000 l/h | .000 | .0000 | 0.00 \X\B0C | Top= 3.60m FCL | CC= -0.31m FFB | 0.00 l/s | 0.00 l/s | 0.0 Pa | 0.00 m/s | X=7.37

# IfcFlowSegment: SS091209005 (88)
Type - Description: Copper pipes length 5 m 22x1 mm; ApplicableOccurrence: Copper; PredefinedType: RIGIDSEGMENT
Type - Pset_ManufacturerTypeInformation - ArticleNumber: SS091209005; ModelReference: Copper pipes length 5 m 22x1 mm; Manufacturer: DDS
Type - Pset_PipeSegmentTypeCommon - NominalDiameter: 20; InnerDiameter: 20; OuterDiameter: 22
Pset_DDS - Flowsegment thickness: x1.0; Drain slope: 1:0; Manufacturer: DDS; Drain slope (%): 10000.0 %; Dimension DN: 20; Width: 20; Project name: OpenBIM; Insulation WSVO: 0; Insulation k-value: 0; Outside dimension: 22.000000; Drain Qww: Qww=0.00 l/s; Product: Copper pipes length 5 m 22x1 mm; Drain slope (\X\B0): 90.0\X\B0; Temperature: 0.00 \X\B0C; Drain DU: DU=0.00 l/s; Product Number: SS091209005; Building Part: Building: 0
AC_Pset_RenovationAndPhasing - Renovation Status: Existing
Name | In | Material | Mtg. Above Slab ref Bottom | Mounting Height | Above Sea Level ref. Bottom | Flow (l/h) | Main string number | Mtg. above Finished Floor ref Center | Pressure drop | Ins thickness | Mtg. Above Slab ref Center | Mtg. Below Ceiling ref Center | Above Sea Level ref. Center | Model Number | Layer number | Pset_DDS, Length | X | Floor number | Velocity | Part number | Peak flow (l/s) | Sub string number | Flow (l/s) | Medium | Y | Mtg. Below Ceiling ref Top | Abs. pressure | Pset_FlowSegmentPipeSegment, Length (mm) | Room number | Room tekst
01.0001.00 | -01 Foundation | ML-Copper pipes length 5 m 22x1 mm-Pipe insulation 9x22 mm gray insulation thickness 9 mm-9 | Edge= -0.02m SSL | 0.00 m | NNUK=-1.02 m | 6731.999856 l/h | 01 | CC= 0.00m FFB | 106751 Pa | ins= 9.000000 mm | CC= 0.00m SSL | CC= 0.67m FCL | NN=-1.00 m | Dra.no: 0 | 2 | 10 | X=29.97 | Storey: 1 | 2.31 m/s | .000 | 0.73 l/s | .0001 | 1.87 l/s | Coldwater | Y=1.03 | Top= 0.00m FCL | 351157.7 Pa | 10148.8 | Pset_DDS - Insulation product text: Pipe insulation; Insulation product number: ZP150/922; Group: Coldwater
01.0001.24 | -01 Foundation | ML-Copper pipes length 5 m 22x1 mm-Pipe insulation 9x22 mm gray insulation thickness 9 mm-9 | Edge= 0.01m SSL | 0.03 m | NNUK=-0.99 m | 6731.999856 l/h | 01 | CC= 0.03m FFB | 106751 Pa | ins= 9.000000 mm | CC= 0.03m SSL | CC= 0.64m FCL | NN=-0.97 m | Dra.no: 0 | 2 | 1 | X=29.97 | Storey: 1 | 2.31 m/s | .024 | 0.73 l/s | .0001 | 1.87 l/s | Coldwater | Y=11.21 | Top= 0.00m FCL | 351157.7 Pa | 720 | Pset_DDS - Insulation product text: Pipe insulation; Insulation product number: ZP150/922; Group: Coldwater
01.0001.00 | 00 Ground floor | ML-Copper pipes length 5 m 22x1 mm | Edge= 2.79m SSL | 2.80 m | NNUK=2.59 m | 0.000000 l/h | 01 | CC= 2.80m FFB | 0 Pa | ins= 0.000000 mm | CC= 2.80m SSL | CC= 0.70m FCL | NN=2.60 m | Dra.no: 1 | 188 | 1 | X=30.85 | Storey: 2 | 0.00 m/s | .000 | 0.00 l/s | .0001 | 0.00 l/s | Cooling Flow | Y=13.25 | Top= 0.00m FCL | 0.0 Pa | 1291.89 | Group: Cooling flow
01.0001.00 | 00 Ground floor | ML-Copper pipes length 5 m 22x1 mm-Pipe insulation 9x22 mm gray insulation thickness 9 mm-9 | Edge= -0.20m SSL | -0.05 m | NNUK=-0.27 m | 6731.999856 l/h | 01 | CC= -0.18m FFB | 106751 Pa | ins= 9.000000 mm | CC= -0.18m SSL | CC= 3.48m FCL | NN=-0.25 m | Dra.no: 1 | 2 | 1 | X=29.97 | Storey: 2 | 2.31 m/s | .000 | 0.73 l/s | .0001 | 1.87 l/s | Coldwater | Y=11.21 | Top= 3.46m FCL | 351157.7 Pa | 520 | 00.27 | Shaft | Pset_DDS - Insulation product text: Pipe insulation; Insulation product number: ZP150/922; System Name: PW; Group: Coldwater
01.0001.00 | 00 Ground floor | ML-Copper pipes length 5 m 22x1 mm | Edge= 2.79m SSL | 2.80 m | NNUK=2.59 m | 0.000000 l/h | 01 | CC= 2.80m FFB | 0 Pa | ins= 0.000000 mm | CC= 2.80m SSL | CC= 0.50m FCL | NN=2.60 m | Dra.no: 1 | 188 | 4 | X=32.17 | Storey: 2 | 0.00 m/s | .000 | 0.00 l/s | .0001 | 0.00 l/s | Cooling Flow | Y=13.28 | Top= 0.49m FCL | 0.0 Pa | 3558.47 | 00.03 | Hallway | Group: Cooling flow
01.0001.27 | 00 Ground floor | ML-Copper pipes length 5 m 22x1 mm-Pipe insulation 9x22 mm gray insulation thickness 9 mm-9 | Edge= 0.35m SSL | 0.50 m | NNUK=0.28 m | 6731.999856 l/h | 01 | CC= 0.37m FFB | 106751 Pa | ins= 9.000000 mm | CC= 0.37m SSL | CC= 2.93m FCL | NN=0.30 m | Dra.no: 1 | 2 | 1 | X=29.97 | Storey: 2 | 2.31 m/s | .027 | 0.73 l/s | .0001 | 1.87 l/s | Coldwater | Y=11.18 | Top= 2.91m FCL | 351157.7 Pa | 528.844 | 00.27 | Shaft | Pset_DDS - Insulation product text: Pipe insulation; Insulation product number: ZP150/922; System Name: PW; Group: Coldwater
01.0001.28 | 00 Ground floor | ML-Copper pipes length 5 m 22x1 mm-Pipe insulation 9x22 mm gray insulation thickness 9 mm-9 | Edge= 0.35m SSL | 0.50 m | NNUK=0.28 m | 6731.999856 l/h | 01 | CC= 0.37m FFB | 106751 Pa | ins= 9.000000 mm | CC= 0.37m SSL | CC= 2.93m FCL | NN=0.30 m | Dra.no: 1 | 2 | 0 | X=29.94 | Storey: 2 | 2.31 m/s | .028 | 0.73 l/s | .0001 | 1.87 l/s | Coldwater | Y=10.62 | Top= 2.91m FCL | 351157.7 Pa | 67.5792 | 00.15 | FB | Pset_DDS - Insulation product text: Pipe insulation; Insulation product number: ZP150/922; System Name: PW; Group: Coldwater
01.0001.29 | 00 Ground floor | ML-Copper pipes length 5 m 22x1 mm-Pipe insulation 9x22 mm gray insulation thickness 9 mm-9 | Edge= 0.35m SSL | 0.50 m | NNUK=0.28 m | 6731.999856 l/h | 01 | CC= 0.37m FFB | 106751 Pa | ins= 9.000000 mm | CC= 0.37m SSL | CC= 2.93m FCL | NN=0.30 m | Dra.no: 1 | 2 | 0 | X=29.80 | Storey: 2 | 2.31 m/s | .029 | 0.73 l/s | .0001 | 1.87 l/s | Coldwater | Y=10.62 | Top= 2.91m FCL | 351157.7 Pa | 64.8098 | 00.15 | FB | Pset_DDS - Insulation product text: Pipe insulation; Insulation product number: ZP150/922; System Name: PW; Group: Coldwater
01.0001.30 | 00 Ground floor | ML-Copper pipes length 5 m 22x1 mm-Pipe insulation 9x22 mm gray insulation thickness 9 mm-9 | Edge= 0.35m SSL | 0.50 m | NNUK=0.28 m | 6731.999856 l/h | 01 | CC= 0.37m FFB | 106751 Pa | ins= 9.000000 mm | CC= 0.37m SSL | CC= 2.93m FCL | NN=0.30 m | Dra.no: 1 | 2 | 0 | X=29.61 | Storey: 2 | 2.31 m/s | .030 | 0.73 l/s | .0001 | 1.87 l/s | Coldwater | Y=10.62 | Top= 2.91m FCL | 351157.7 Pa | 70.0306 | 00.15 | FB | Pset_DDS - Insulation product text: Pipe insulation; Insulation product number: ZP150/922; System Name: PW; Group: Coldwater
01.0001.31 | 00 Ground floor | ML-Copper pipes length 5 m 22x1 mm-Pipe insulation 9x22 mm gray insulation thickness 9 mm-9 | Edge= 0.35m SSL | 0.50 m | NNUK=0.28 m | 6731.999856 l/h | 01 | CC= 0.37m FFB | 106751 Pa | ins= 9.000000 mm | CC= 0.37m SSL | CC= 2.93m FCL | NN=0.30 m | Dra.no: 1 | 2 | 0 | X=29.46 | Storey: 2 | 2.31 m/s | .031 | 0.73 l/s | .0001 | 1.87 l/s | Coldwater | Y=10.62 | Top= 2.91m FCL | 351157.7 Pa | 70.0306 | 00.15 | FB | Pset_DDS - Insulation product text: Pipe insulation; Insulation product number: ZP150/922; System Name: PW; Group: Coldwater
01.0001.32 | 00 Ground floor | ML-Copper pipes length 5 m 22x1 mm-Pipe insulation 9x22 mm gray insulation thickness 9 mm-9 | Edge= 0.35m SSL | 0.50 m | NNUK=0.28 m | 6731.999856 l/h | 01 | CC= 0.37m FFB | 106751 Pa | ins= 9.000000 mm | CC= 0.37m SSL | CC= 2.93m FCL | NN=0.30 m | Dra.no: 1 | 2 | 0 | X=29.36 | Storey: 2 | 2.31 m/s | .032 | 0.73 l/s | .0001 | 1.87 l/s | Coldwater | Y=10.65 | Top= 2.91m FCL | 351157.7 Pa | 256.528 | 00.15 | FB | Pset_DDS - Insulation product text: Pipe insulation; Insulation product number: ZP150/922; System Name: PW; Group: Coldwater
01.0001.33 | 00 Ground floor | ML-Copper pipes length 5 m 22x1 mm-Pipe insulation 9x22 mm gray insulation thickness 9 mm-9 | Edge= 0.38m SSL | 0.53 m | NNUK=0.31 m | 6731.999856 l/h | 01 | CC= 0.40m FFB | 106751 Pa | ins= 9.000000 mm | CC= 0.40m SSL | CC= 2.90m FCL | NN=0.33 m | Dra.no: 1 | 2 | 3 | X=29.36 | Storey: 2 | 2.31 m/s | .033 | 0.73 l/s | .0001 | 1.87 l/s | Coldwater | Y=10.94 | Top= 2.88m FCL | 351157.7 Pa | 2554 | 00.27 | Shaft | Pset_DDS - Insulation product text: Pipe insulation; Insulation product number: ZP150/922; System Name: PW; Group: Coldwater
01.0002.00 | 00 Ground floor | ML-Copper pipes length 5 m 22x1 mm-Pipe insulation 9x22 mm gray insulation thickness 9 mm-9 | Edge= 2.97m SSL | 3.12 m | NNUK=2.90 m | 3131.999937 l/h | 01 | CC= 2.99m FFB | 16914 Pa | ins= 9.000000 mm | CC= 2.99m SSL | CC= 0.31m FCL | NN=2.92 m | Dra.no: 1 | 2 | 0 | X=29.36 | Storey: 2 | 2.49 m/s | .000 | 0.50 l/s | .0002 | 0.87 l/s | Coldwater | Y=10.94 | Top= 0.30m FCL | 244406.6 Pa | 41 | 00.27 | Shaft | Pset_DDS - Insulation product text: Pipe insulation; Insulation product number: ZP150/922; System Name: PW; Group: Coldwater
01.0023.00 | 00 Ground floor | ML-Copper pipes length 5 m 22x1 mm-Pipe insulation 9x22 mm gray insulation thickness 9 mm-9 | Edge= 2.95m SSL | 3.10 m | NNUK=2.88 m | 3599.999920 l/h | 01 | CC= 2.97m FFB | 12204 Pa | ins= 9.000000 mm | CC= 2.97m SSL | CC= 0.33m FCL | NN=2.90 m | Dra.no: 1 | 2 | 6 | X=29.34 | Storey: 2 | 1.72 m/s | .000 | 0.54 l/s | .0023 | 1.00 l/s | Coldwater | Y=10.94 | Top= 0.31m FCL | 168595.7 Pa | 6229.94 | 00.27 | Shaft | Pset_DDS - Insulation product text: Pipe insulation; Insulation product number: ZP150/922; System Name: PW; Group: Coldwater
01.0024.00 | 00 Ground floor | ML-Copper pipes length 5 m 22x1 mm-Pipe insulation 9x22 mm gray insulation thickness 9 mm-9 | Edge= 3.08m SSL | 3.10 m | NNUK=2.88 m | 3347.999918 l/h | 01 | CC= 3.10m FFB | 2662 Pa | ins= 9.000000 mm | CC= 3.10m SSL | CC= 0.40m FCL | NN=2.90 m | Dra.no: 1 | 2 | 1 | X=23.10 | Storey: 2 | 1.65 m/s | .000 | 0.52 l/s | .0024 | 0.93 l/s | Coldwater | Y=10.94 | Top= 0.38m FCL | 156391.5 Pa | 1095.96 | 00.01 | Entrance | Pset_DDS - Insulation product text: Pipe insulation; Insulation product number: ZP150/922; System Name: PW; Group: Coldwater
01.0025.00 | 00 Ground floor | ML-Copper pipes length 5 m 22x1 mm-Pipe insulation 9x22 mm gray insulation thickness 9 mm-9 | Edge= 3.08m SSL | 3.10 m | NNUK=2.88 m | 1403.999949 l/h | 01 | CC= 3.10m FFB | 25583 Pa | ins= 9.000000 mm | CC= 3.10m SSL | CC= 0.40m FCL | NN=2.90 m | Dra.no: 1 | 2 | 0 | X=21.98 | Storey: 2 | 2.24 m/s | .000 | 0.30 l/s | .0025 | 0.39 l/s | Coldwater | Y=10.94 | Top= 0.38m FCL | 113847.8 Pa | 53.0373 | 00.01 | Entrance | Pset_DDS - Insulation product text: Pipe insulation; Insulation product number: ZP150/922; System Name: PW; Group: Coldwater
02.0002.00 | 00 Ground floor | ML-Copper pipes length 5 m 22x1 mm | Edge= 2.79m SSL | 2.80 m | NNUK=2.59 m | 0.000000 l/h | 02 | CC= 2.80m FFB | 0 Pa | ins= 0.000000 mm | CC= 2.80m SSL | CC= 0.50m FCL | NN=2.60 m | Dra.no: 1 | 188 | 0 | X=32.17 | Storey: 2 | 0.00 m/s | .000 | 0.00 l/s | .0002 | 0.00 l/s | Cooling Flow | Y=16.86 | Top= 0.49m FCL | 0.0 Pa | 24.5634 | 00.03 | Hallway | Group: Cooling flow; Pset_DDS - System Name: Cooling
03.0002.00 | 00 Ground floor | ML-Copper pipes length 5 m 22x1 mm | Edge= 2.79m SSL | 2.80 m | NNUK=2.59 m | 0.000000 l/h | 03 | CC= 2.80m FFB | 0 Pa | ins= 0.000000 mm | CC= 2.80m SSL | CC= 0.50m FCL | NN=2.60 m | Dra.no: 1 | 189 | 0 | X=32.23 | Storey: 2 | 0.00 m/s | .000 | 0.00 l/s | .0002 | 0.00 l/s | Cooling return | Y=16.79 | Top= 0.49m FCL | 0.0 Pa | 23.8179 | 00.03 | Hallway | Group: Cooling return; Pset_DDS - System Name: Cooling
Pipe | 00 Ground floor | ML-Copper pipes length 5 m 22x1 mm | Edge= 2.79m SSL | 2.80 m | NNUK=2.59 m | 0.000000 l/h | 00 | CC= 2.80m FFB | 0 Pa | ins= 0.000000 mm | CC= 2.80m SSL | CC= 0.70m FCL | NN=2.60 m | Dra.no: 1 | 189 | 1 | X=30.85 | Storey: 2 | 0.00 m/s | .000 | 0.00 l/s | .0001 | 0.00 l/s | Cooling return | Y=13.18 | Top= 0.00m FCL | 0.0 Pa | 1348.14
Pipe | 00 Ground floor | ML-Copper pipes length 5 m 22x1 mm | Edge= 2.79m SSL | 2.80 m | NNUK=2.59 m | 0.000000 l/h | 00 | CC= 2.80m FFB | 0 Pa | ins= 0.000000 mm | CC= 2.80m SSL | CC= 0.50m FCL | NN=2.60 m | Dra.no: 1 | 189 | 4 | X=32.23 | Storey: 2 | 0.00 m/s | .000 | 0.00 l/s | .0001 | 0.00 l/s | Cooling return | Y=13.21 | Top= 0.49m FCL | 0.0 Pa | 3558.47 | 00.03 | Hallway
Pipe | 00 Ground floor | ML-Copper pipes length 5 m 22x1 mm | Edge= -0.05m SSL | 0.09 m | NNUK=-0.12 m | 0.000000 l/h | 00 | CC= -0.04m FFB | 0 Pa | ins= 0.000000 mm | CC= -0.04m SSL | CC= 3.34m FCL | NN=-0.11 m | Dra.no: 1 | 5 | 0 | X=34.62 | Storey: 2 | 0.00 m/s | .000 | 0.00 l/s | .0000 | 0.00 l/s | Heat flow | Y=6.98 | Top= 3.33m FCL | 0.0 Pa | 53.0373 | 00.25 | Director office
Pipe | 00 Ground floor | ML-Copper pipes length 5 m 22x1 mm | Edge= -0.31m SSL | -0.17 m | NNUK=-0.38 m | 0.000000 l/h | 00 | CC= -0.30m FFB | 0 Pa | ins= 0.000000 mm | CC= -0.30m SSL | CC= 3.60m FCL | NN=-0.37 m | Dra.no: 1 | 5 | 0 | X=34.62 | Storey: 2 | 0.00 m/s | .000 | 0.00 l/s | .0000 | 0.00 l/s | Heat flow | Y=6.95 | Top= 3.59m FCL | 0.0 Pa | 230 | 00.25 | Director office
Pipe | 00 Ground floor | ML-Copper pipes length 5 m 22x1 mm | Edge= -0.34m SSL | -0.20 m | NNUK=-0.41 m | 0.000000 l/h | 00 | CC= -0.33m FFB | 0 Pa | ins= 0.000000 mm | CC= -0.33m SSL | CC= 3.63m FCL | NN=-0.40 m | Dra.no: 1 | 5 | 0 | X=34.62 | Storey: 2 | 0.00 m/s | .000 | 0.00 l/s | .0000 | 0.00 l/s | Heat flow | Y=7.13 | Top= 3.62m FCL | 0.0 Pa | 157.72 | 00.25 | Director office
Pipe | 00 Ground floor | ML-Copper pipes length 5 m 22x1 mm | Edge= -0.09m SSL | -0.20 m | NNUK=-0.41 m | 0.000000 l/h | 00 | CC= -0.08m FFB | 0 Pa | ins= 0.000000 mm | CC= -0.08m SSL | CC= 3.38m FCL | NN=-0.40 m | Dra.no: 1 | 5 | 4 | X=38.34 | Storey: 2 | 0.00 m/s | .000 | 0.00 l/s | .0000 | 0.00 l/s | Heat flow | Y=7.16 | Top= 3.37m FCL | 0.0 Pa | 3693.56 | 00.24 | Director office
Pipe | 00 Ground floor | ML-Copper pipes length 5 m 22x1 mm | Edge= -0.09m SSL | -0.20 m | NNUK=-0.41 m | 0.000000 l/h | 00 | CC= -0.08m FFB | 0 Pa | ins= 0.000000 mm | CC= -0.08m SSL | CC= 3.38m FCL | NN=-0.40 m | Dra.no: 1 | 5 | 2 | X=40.62 | Storey: 2 | 0.00 m/s | .000 | 0.00 l/s | .0000 | 0.00 l/s | Heat flow | Y=7.16 | Top= 3.37m FCL | 0.0 Pa | 2253.92 | 00.24 | Director office
Pipe | 00 Ground floor | ML-Copper pipes length 5 m 22x1 mm | Edge= -0.09m SSL | -0.20 m | NNUK=-0.41 m | 0.000000 l/h | 00 | CC= -0.08m FFB | 0 Pa | ins= 0.000000 mm | CC= -0.08m SSL | CC= 3.38m FCL | NN=-0.40 m | Dra.no: 1 | 5 | 6 | X=40.65 | Storey: 2 | 0.00 m/s | .000 | 0.00 l/s | .0000 | 0.00 l/s | Heat flow | Y=12.70 | Top= 3.37m FCL | 0.0 Pa | 5510.83 | 00.12 | Storage
Pipe | 00 Ground floor | ML-Copper pipes length 5 m 22x1 mm | Edge= -0.09m SSL | -0.20 m | NNUK=-0.41 m | 0.000000 l/h | 00 | CC= -0.08m FFB | 0 Pa | ins= 0.000000 mm | CC= -0.08m SSL | CC= 3.38m FCL | NN=-0.40 m | Dra.no: 1 | 5 | 6 | X=40.65 | Storey: 2 | 0.00 m/s | .000 | 0.00 l/s | .0000 | 0.00 l/s | Heat flow | Y=18.47 | Top= 3.37m FCL | 0.0 Pa | 5745.65 | 00.23 | Office
Pipe | 00 Ground floor | ML-Copper pipes length 5 m 22x1 mm | Edge= -0.09m SSL | -0.20 m | NNUK=-0.41 m | 0.000000 l/h | 00 | CC= -0.08m FFB | 0 Pa | ins= 0.000000 mm | CC= -0.08m SSL | CC= 3.38m FCL | NN=-0.40 m | Dra.no: 1 | 5 | 4 | X=40.65 | Storey: 2 | 0.00 m/s | .000 | 0.00 l/s | .0000 | 0.00 l/s | Heat flow | Y=22.06 | Top= 3.37m FCL | 0.0 Pa | 3569.73 | 00.23 | Office
Pipe | 00 Ground floor | ML-Copper pipes length 5 m 22x1 mm | Edge= -0.09m SSL | -0.20 m | NNUK=-0.41 m | 0.000000 l/h | 00 | CC= -0.08m FFB | 0 Pa | ins= 0.000000 mm | CC= -0.08m SSL | CC= 3.38m FCL | NN=-0.40 m | Dra.no: 1 | 5 | 3 | X=37.96 | Storey: 2 | 0.00 m/s | .000 | 0.00 l/s | .0000 | 0.00 l/s | Heat flow | Y=22.09 | Top= 3.37m FCL | 0.0 Pa | 2659.59 | 00.23 | Office
Pipe | 00 Ground floor | ML-Copper pipes length 5 m 22x1 mm | Edge= -0.09m SSL | -0.20 m | NNUK=-0.41 m | 0.000000 l/h | 00 | CC= -0.08m FFB | 0 Pa | ins= 0.000000 mm | CC= -0.08m SSL | CC= 3.38m FCL | NN=-0.40 m | Dra.no: 1 | 5 | 3 | X=35.40 | Storey: 2 | 0.00 m/s | .000 | 0.00 l/s | .0000 | 0.00 l/s | Heat flow | Y=22.09 | Top= 3.37m FCL | 0.0 Pa | 2535.5 | 00.23 | Office
Pipe | 00 Ground floor | ML-Copper pipes length 5 m 22x1 mm | Edge= -0.21m SSL | -0.20 m | NNUK=-0.41 m | 0.000000 l/h | 00 | CC= -0.20m FFB | 0 Pa | ins= 0.000000 mm | CC= -0.20m SSL | CC= 3.50m FCL | NN=-0.40 m | Dra.no: 1 | 5 | 5 | X=30.33 | Storey: 2 | 0.00 m/s | .000 | 0.00 l/s | .0000 | 0.00 l/s | Heat flow | Y=22.09 | Top= 3.49m FCL | 0.0 Pa | 5043 | 00.03 | Hallway
Pipe | 00 Ground floor | ML-Copper pipes length 5 m 22x1 mm | Edge= -0.21m SSL | -0.20 m | NNUK=-0.41 m | 0.000000 l/h | 00 | CC= -0.20m FFB | 0 Pa | ins= 0.000000 mm | CC= -0.20m SSL | CC= 3.50m FCL | NN=-0.40 m | Dra.no: 1 | 5 | 2 | X=28.69 | Storey: 2 | 0.00 m/s | .000 | 0.00 l/s | .0000 | 0.00 l/s | Heat flow | Y=22.09 | Top= 3.49m FCL | 0.0 Pa | 1618.08 | 00.03 | Hallway
Pipe | 00 Ground floor | ML-Copper pipes length 5 m 22x1 mm | Edge= -0.21m SSL | -0.20 m | NNUK=-0.41 m | 0.000000 l/h | 00 | CC= -0.20m FFB | 0 Pa | ins= 0.000000 mm | CC= -0.20m SSL | CC= 3.50m FCL | NN=-0.40 m | Dra.no: 1 | 5 | 10 | X=28.67 | Storey: 2 | 0.00 m/s | .000 | 0.00 l/s | .0000 | 0.00 l/s | Heat flow | Y=11.97 | Top= 3.49m FCL | 0.0 Pa | 10096.5 | 00.03 | Hallway
Pipe | 00 Ground floor | ML-Copper pipes length 5 m 22x1 mm | Edge= -0.34m SSL | -0.20 m | NNUK=-0.41 m | 0.000000 l/h | 00 | CC= -0.33m FFB | 0 Pa | ins= 0.000000 mm | CC= -0.33m SSL | CC= 3.63m FCL | NN=-0.40 m | Dra.no: 1 | 5 | 1 | X=29.22 | Storey: 2 | 0.00 m/s | .000 | 0.00 l/s | .0000 | 0.00 l/s | Heat flow | Y=11.94 | Top= 3.62m FCL | 0.0 Pa | 525.453 | 00.27 | Shaft
Pipe | 00 Ground floor | ML-Copper pipes length 5 m 22x1 mm | Edge= -0.34m SSL | -0.20 m | NNUK=-0.41 m | 0.000000 l/h | 00 | CC= -0.33m FFB | 0 Pa | ins= 0.000000 mm | CC= -0.33m SSL | CC= 3.63m FCL | NN=-0.40 m | Dra.no: 1 | 5 | 0 | X=29.27 | Storey: 2 | 0.00 m/s | .000 | 0.00 l/s | .0000 | 0.00 l/s | Heat flow | Y=11.94 | Top= 3.62m FCL | 0.0 Pa | 47.1712 | 00.27 | Shaft
Pipe | 00 Ground floor | ML-Copper pipes length 5 m 22x1 mm | Edge= 0.01m SSL | -0.10 m | NNUK=-0.31 m | 0.000000 l/h | 00 | CC= 0.02m FFB | 0 Pa | ins= 0.000000 mm | CC= 0.02m SSL | CC= 3.28m FCL | NN=-0.30 m | Dra.no: 1 | 6 | 2 | X=40.51 | Storey: 2 | 0.00 m/s | .000 | 0.00 l/s | .0000 | 0.00 l/s | Heat return | Y=7.27 | Top= 3.27m FCL | 0.0 Pa | 2196.74 | 00.24 | Director office
Pipe | 00 Ground floor | ML-Copper pipes length 5 m 22x1 mm | Edge= 0.01m SSL | -0.10 m | NNUK=-0.31 m | 0.000000 l/h | 00 | CC= 0.02m FFB | 0 Pa | ins= 0.000000 mm | CC= 0.02m SSL | CC= 3.28m FCL | NN=-0.30 m | Dra.no: 1 | 6 | 5 | X=40.54 | Storey: 2 | 0.00 m/s | .000 | 0.00 l/s | .0000 | 0.00 l/s | Heat return | Y=12.65 | Top= 3.27m FCL | 0.0 Pa | 5356.85 | 00.12 | Storage
Pipe | 00 Ground floor | ML-Copper pipes length 5 m 22x1 mm | Edge= 0.01m SSL | -0.10 m | NNUK=-0.31 m | 0.000000 l/h | 00 | CC= 0.02m FFB | 0 Pa | ins= 0.000000 mm | CC= 0.02m SSL | CC= 3.28m FCL | NN=-0.30 m | Dra.no: 1 | 6 | 6 | X=40.54 | Storey: 2 | 0.00 m/s | .000 | 0.00 l/s | .0000 | 0.00 l/s | Heat return | Y=18.42 | Top= 3.27m FCL | 0.0 Pa | 5745.65 | 00.23 | Office
Pipe | 00 Ground floor | ML-Copper pipes length 5 m 22x1 mm | Edge= 0.01m SSL | -0.10 m | NNUK=-0.31 m | 0.000000 l/h | 00 | CC= 0.02m FFB | 0 Pa | ins= 0.000000 mm | CC= 0.02m SSL | CC= 3.28m FCL | NN=-0.30 m | Dra.no: 1 | 6 | 3 | X=40.54 | Storey: 2 | 0.00 m/s | .000 | 0.00 l/s | .0000 | 0.00 l/s | Heat return | Y=21.93 | Top= 3.27m FCL | 0.0 Pa | 3491.71 | 00.23 | Office
Pipe | 00 Ground floor | ML-Copper pipes length 5 m 22x1 mm | Edge= 0.01m SSL | -0.10 m | NNUK=-0.31 m | 0.000000 l/h | 00 | CC= 0.02m FFB | 0 Pa | ins= 0.000000 mm | CC= 0.02m SSL | CC= 3.28m FCL | NN=-0.30 m | Dra.no: 1 | 6 | 3 | X=38.01 | Storey: 2 | 0.00 m/s | .000 | 0.00 l/s | .0000 | 0.00 l/s | Heat return | Y=21.96 | Top= 3.27m FCL | 0.0 Pa | 2502.42 | 00.23 | Office
Pipe | 00 Ground floor | ML-Copper pipes length 5 m 22x1 mm | Edge= 0.01m SSL | -0.10 m | NNUK=-0.31 m | 0.000000 l/h | 00 | CC= 0.02m FFB | 0 Pa | ins= 0.000000 mm | CC= 0.02m SSL | CC= 3.28m FCL | NN=-0.30 m | Dra.no: 1 | 6 | 3 | X=35.45 | Storey: 2 | 0.00 m/s | .000 | 0.00 l/s | .0000 | 0.00 l/s | Heat return | Y=21.96 | Top= 3.27m FCL | 0.0 Pa | 2535.5 | 00.23 | Office
Pipe | 00 Ground floor | ML-Copper pipes length 5 m 22x1 mm | Edge= -0.11m SSL | -0.10 m | NNUK=-0.31 m | 0.000000 l/h | 00 | CC= -0.10m FFB | 0 Pa | ins= 0.000000 mm | CC= -0.10m SSL | CC= 3.40m FCL | NN=-0.30 m | Dra.no: 1 | 6 | 5 | X=30.38 | Storey: 2 | 0.00 m/s | .000 | 0.00 l/s | .0000 | 0.00 l/s | Heat return | Y=21.96 | Top= 3.39m FCL | 0.0 Pa | 5043 | 00.03 | Hallway
Pipe | 00 Ground floor | ML-Copper pipes length 5 m 22x1 mm | Edge= -0.11m SSL | -0.10 m | NNUK=-0.31 m | 0.000000 l/h | 00 | CC= -0.10m FFB | 0 Pa | ins= 0.000000 mm | CC= -0.10m SSL | CC= 3.40m FCL | NN=-0.30 m | Dra.no: 1 | 6 | 2 | X=28.60 | Storey: 2 | 0.00 m/s | .000 | 0.00 l/s | .0000 | 0.00 l/s | Heat return | Y=21.96 | Top= 3.39m FCL | 0.0 Pa | 1766.48 | 00.03 | Hallway
Pipe | 00 Ground floor | ML-Copper pipes length 5 m 22x1 mm | Edge= -0.11m SSL | -0.10 m | NNUK=-0.31 m | 0.000000 l/h | 00 | CC= -0.10m FFB | 0 Pa | ins= 0.000000 mm | CC= -0.10m SSL | CC= 3.60m FCL | NN=-0.30 m | Dra.no: 1 | 6 | 10 | X=28.57 | Storey: 2 | 0.00 m/s | .000 | 0.00 l/s | .0000 | 0.00 l/s | Heat return | Y=11.86 | Top= 3.59m FCL | 0.0 Pa | 10076.3 | 00.01 | Entrance
Pipe | 00 Ground floor | ML-Copper pipes length 5 m 22x1 mm | Edge= -0.24m SSL | -0.10 m | NNUK=-0.31 m | 0.000000 l/h | 00 | CC= -0.23m FFB | 0 Pa | ins= 0.000000 mm | CC= -0.23m SSL | CC= 3.53m FCL | NN=-0.30 m | Dra.no: 1 | 6 | 1 | X=29.23 | Storey: 2 | 0.00 m/s | .000 | 0.00 l/s | .0000 | 0.00 l/s | Heat return | Y=11.83 | Top= 3.52m FCL | 0.0 Pa | 629.824 | 00.27 | Shaft
Pipe | 00 Ground floor | ML-Copper pipes length 5 m 22x1 mm | Edge= -0.24m SSL | -0.10 m | NNUK=-0.31 m | 0.000000 l/h | 00 | CC= -0.23m FFB | 0 Pa | ins= 0.000000 mm | CC= -0.23m SSL | CC= 3.53m FCL | NN=-0.30 m | Dra.no: 1 | 6 | 0 | X=29.27 | Storey: 2 | 0.00 m/s | .000 | 0.00 l/s | .0000 | 0.00 l/s | Heat return | Y=11.83 | Top= 3.52m FCL | 0.0 Pa | 41 | 00.27 | Shaft
