Properties of the parts of a building model (IFC2X3), part 5 of 14

# IfcFlowFitting: BE83051600xx (36)
Name | In | Rotation | Above Sea Level ref. Bottom | Mounting Height | X | Above Sea Level ref. Center | Mtg. Below Ceiling ref Center | Mtg. Above Slab ref Bottom | Mtg. above Finished Floor ref Center | Mtg. Above Slab ref Center | Mtg. Below Ceiling ref Top | Sub string number | Room tekst | Model Number | Part number | Y | Room number | Abs. pressure | Floor number
1.36.4 | 01 First floor | 270.000000 | NNUK=5.99 m | 2.85 m | X=11.41 | NN=6.15 m | CC= 0.33m FCL | Edge= 2.89m SSL | CC= 2.97m FFB | CC= 2.97m SSL | Top= 0.25m FCL | .0036 | Office | Dra.no: 2 | .004 | Y=19.57 | 01.18 | 278.4 Pa | Storey: 3
1.37.2 | 01 First floor | 90.000000 | NNUK=6.14 m | 3.00 m | X=13.69 | NN=6.30 m | CC= 0.18m FCL | Edge= 3.04m SSL | CC= 3.12m FFB | CC= 3.12m SSL | Top= 0.10m FCL | .0037 | Office | Dra.no: 2 | .002 | Y=18.69 | 01.20 | 281.5 Pa | Storey: 3
1.37.4 | 01 First floor | 270.000000 | NNUK=5.99 m | 2.85 m | X=13.69 | NN=6.15 m | CC= 0.33m FCL | Edge= 2.89m SSL | CC= 2.97m FFB | CC= 2.97m SSL | Top= 0.25m FCL | .0037 | Office | Dra.no: 2 | .004 | Y=19.57 | 01.20 | 278.2 Pa | Storey: 3
1.38.2 | 01 First floor | 90.000000 | NNUK=6.14 m | 3.00 m | X=15.56 | NN=6.30 m | CC= 0.18m FCL | Edge= 3.04m SSL | CC= 3.12m FFB | CC= 3.12m SSL | Top= 0.10m FCL | .0038 | Office | Dra.no: 2 | .002 | Y=18.69 | 01.20 | 281.3 Pa | Storey: 3
1.38.4 | 01 First floor | 270.000000 | NNUK=5.99 m | 2.85 m | X=15.56 | NN=6.15 m | CC= 0.33m FCL | Edge= 2.89m SSL | CC= 2.97m FFB | CC= 2.97m SSL | Top= 0.25m FCL | .0038 | Office | Dra.no: 2 | .004 | Y=19.57 | 01.20 | 277.9 Pa | Storey: 3
1.39.2 | 01 First floor | 90.000000 | NNUK=6.14 m | 3.00 m | X=18.19 | NN=6.30 m | CC= 0.18m FCL | Edge= 3.04m SSL | CC= 3.12m FFB | CC= 3.12m SSL | Top= 0.10m FCL | .0039 | Office | Dra.no: 2 | .002 | Y=18.69 | 01.19 | 281.0 Pa | Storey: 3
1.39.4 | 01 First floor | 270.000000 | NNUK=5.99 m | 2.85 m | X=18.19 | NN=6.15 m | CC= 0.33m FCL | Edge= 2.89m SSL | CC= 2.97m FFB | CC= 2.97m SSL | Top= 0.25m FCL | .0039 | Office | Dra.no: 2 | .004 | Y=19.57 | 01.19 | 277.6 Pa | Storey: 3
1.40.2 | 01 First floor | 90.000000 | NNUK=6.14 m | 3.00 m | X=20.06 | NN=6.30 m | CC= 0.18m FCL | Edge= 3.04m SSL | CC= 3.12m FFB | CC= 3.12m SSL | Top= 0.10m FCL | .0040 | Office | Dra.no: 2 | .002 | Y=18.69 | 01.19 | 280.7 Pa | Storey: 3
1.40.4 | 01 First floor | 270.000000 | NNUK=5.99 m | 2.85 m | X=20.06 | NN=6.15 m | CC= 0.33m FCL | Edge= 2.89m SSL | CC= 2.97m FFB | CC= 2.97m SSL | Top= 0.25m FCL | .0040 | Office | Dra.no: 2 | .004 | Y=19.57 | 01.19 | 277.3 Pa | Storey: 3
1.41.2 | 01 First floor | 90.000000 | NNUK=6.14 m | 3.00 m | X=22.19 | NN=6.30 m | CC= 0.18m FCL | Edge= 3.04m SSL | CC= 3.12m FFB | CC= 3.12m SSL | Top= 0.10m FCL | .0041 | Storage | Dra.no: 2 | .002 | Y=18.69 | 01.13 | 280.4 Pa | Storey: 3
1.41.4 | 01 First floor | 270.000000 | NNUK=5.99 m | 2.85 m | X=22.19 | NN=6.15 m | CC= 0.33m FCL | Edge= 2.89m SSL | CC= 2.97m FFB | CC= 2.97m SSL | Top= 0.25m FCL | .0041 | Storage | Dra.no: 2 | .004 | Y=19.57 | 01.13 | 277.0 Pa | Storey: 3

# IfcFlowFitting: CH3000018015 (10)
Type - Description: Cu fitting reducer 18/15; ApplicableOccurrence: Basic; PredefinedType: TRANSITION
Type - Pset_ManufacturerTypeInformation - ArticleNumber: CH3000018015; ModelReference: Cu fitting reducer 18/15; Manufacturer: DDS
Type - Pset_PipeFittingTypeCommon - NominalDiameter: 15, 12; InnerDiameter: 16, 13; OuterDiameter: 18, 15
Material: IFC Building Material
Pset_DDS - Pipe thickness:: x1.0; Product: Cu fitting reducer 18/15; Manufacturer: DDS; Length: 7.5 m; Outside dimension: 18.000000; Project name: OpenBIM; Height: 0; Insulation k-value: 0; Insulation WSVO: 0; Width: 15; Product Number: CH3000018015; Dimension DN: 15 mm; Building Part: Building: 0; Abs. pressure: 0.0 Pa
AC_Pset_RenovationAndPhasing - Renovation Status: Existing
Name | In | Flow (l/s) | Mounting Height | X | Flow (l/h) | Y | Insulation product text | Mtg. Below Ceiling ref Center | Main string number | Sub string number | Above Sea Level ref. Bottom | Mtg. above Finished Floor ref Center | Ins thickness | Mtg. Above Slab ref Center | Insulation product number | System Name | Model Number | Layer number | Flow (m\X\B3/h) | Floor number | Mtg. Above Slab ref Bottom | Room tekst | Pressure drop | Above Sea Level ref. Center | Part number | Room number | Mtg. Below Ceiling ref Top | Rotation | Medium | Velocity | Group
1.32.0 | 00 Ground floor | 0.34 l/s | 3.10 m | X=21.99 | 1223.999986 l/h | Y=12.82 | Pipe insulation | CC= 0.20m FCL | 01 | .0032 | NNUK=2.89 m | CC= 3.10m FFB | ins= 9.000000 mm | CC= 3.10m SSL | ZP150/918 | PW | Dra.no: 1 | 2 | 1.2 m\X\B3/h | Storey: 2 | Edge= 3.09m SSL | corridor | 4058 | NN=2.90 m | .000 | 00.04 | Top= 0.19m FCL | 0.000000 | Coldwater | 2.00 m/s | Coldwater
2.2.0 | 00 Ground floor | 0.00 l/s | 2.90 m | X=35.58 | 0.000000 l/h | Y=20.48 |  | CC= 0.28m FCL | 02 | .0002 | NNUK=2.69 m | CC= 3.02m FFB | ins= 0.000000 mm | CC= 3.02m SSL |  | Cooling | Dra.no: 1 | 188 | 0.0 m\X\B3/h | Storey: 2 | Edge= 3.01m SSL | Office | 0 | NN=2.70 m | .000 | 00.23 | Top= 0.27m FCL | 0.000000 | Cooling Flow | 0.00 m/s | Cooling flow
2.6.1 | 00 Ground floor | 0.00 l/s | 3.10 m | X=35.58 | 0.000000 l/h | Y=16.85 |  | CC= 0.08m FCL | 02 | .0006 | NNUK=2.88 m | CC= 3.22m FFB | ins= 0.000000 mm | CC= 3.22m SSL |  | Cooling | Dra.no: 1 | 188 | 0.0 m\X\B3/h | Storey: 2 | Edge= 3.21m SSL | Office | 0 | NN=2.90 m | .001 | 00.23 | Top= 0.07m FCL | 359.982284 | Cooling Flow | 0.00 m/s | Cooling flow
3.2.0 | 00 Ground floor | 0.00 l/s | 3.00 m | X=35.52 | 0.000000 l/h | Y=20.42 |  | CC= 0.18m FCL | 03 | .0002 | NNUK=2.79 m | CC= 3.12m FFB | ins= 0.000000 mm | CC= 3.12m SSL |  | Cooling | Dra.no: 1 | 189 | 0.0 m\X\B3/h | Storey: 2 | Edge= 3.11m SSL | Office | 0 | NN=2.80 m | .000 | 00.23 | Top= 0.17m FCL | 0.000000 | Cooling return | 0.00 m/s | Cooling return
3.6.1 | 00 Ground floor | 0.00 l/s | 3.00 m | X=35.52 | 0.000000 l/h | Y=16.78 |  | CC= 0.18m FCL | 03 | .0006 | NNUK=2.79 m | CC= 3.12m FFB | ins= 0.000000 mm | CC= 3.12m SSL |  | Cooling | Dra.no: 1 | 189 | 0.0 m\X\B3/h | Storey: 2 | Edge= 3.11m SSL | Office | 0 | NN=2.80 m | .001 | 00.23 | Top= 0.17m FCL | 0.000000 | Cooling return | 0.00 m/s | Cooling return
1.13.0 | 01 First floor | 0.34 l/s | 2.80 m | X=22.16 | 1223.999986 l/h | Y=12.79 | Pipe insulation | CC= 0.63m FCL | 01 | .0013 | NNUK=6.09 m | CC= 2.67m FFB | ins= 9.000000 mm | CC= 2.67m SSL | ZP150/918 | PW | Dra.no: 2 | 2 | 1.2 m\X\B3/h | Storey: 3 | Edge= 2.66m SSL | corridor | 4225 | NN=6.10 m | .000 | 01.04 | Top= 0.62m FCL | 0.000000 | Coldwater | 2.00 m/s | Coldwater
1.3.0 | 01 First floor | 0.00 l/s | 2.86 m | X=29.36 | 0.000000 l/h | Y=10.94 | Pipe insulation | CC= 0.44m FCL | 01 | .0003 | NNUK=6.15 m | CC= 2.86m FFB | ins= 9.000000 mm | CC= 2.86m SSL | ZP150/918 | PW | Dra.no: 2 | 2 | 0.0 m\X\B3/h | Storey: 3 | Edge= 2.85m SSL |  | 0 | NN=6.16 m | .000 |  | Top= 0.00m FCL | 0.000000 | Coldwater | 0.00 m/s | Coldwater
1.6.0 | 01 First floor | 0.26 l/s | 2.80 m | X=22.06 | 935.999966 l/h | Y=10.94 | Pipe insulation | CC= 0.63m FCL | 01 | .0006 | NNUK=6.09 m | CC= 2.67m FFB | ins= 9.000000 mm | CC= 2.67m SSL | ZP150/918 | PW | Dra.no: 2 | 2 | 0.9 m\X\B3/h | Storey: 3 | Edge= 2.66m SSL | Restaurant | 13548 | NN=6.10 m | .000 | 01.03 | Top= 0.62m FCL | 0.000000 | Coldwater | 1.55 m/s | Coldwater
2.2.0 | 01 First floor | 0.35 l/s | 2.82 m | X=29.36 | 1260.000005 l/h | Y=11.09 | Pipe insulation | CC= 0.49m FCL | 02 | .0002 | NNUK=6.10 m | CC= 2.82m FFB | ins= 9.000000 mm | CC= 2.82m SSL | ZP150/918 |  | Dra.no: 2 | 3 | 1.3 m\X\B3/h | Storey: 3 | Edge= 2.81m SSL |  | 37075 | NN=6.12 m | .000 |  | Top= 0.00m FCL | 0.000000 | Hotwater | 2.05 m/s | Hotwater
3.2.0 | 01 First floor | 0.04 l/s | 2.89 m | X=29.36 | 151.334382 l/h | Y=11.33 | Pipe insulation | CC= 0.41m FCL | 03 | .0002 | NNUK=6.18 m | CC= 2.89m FFB | ins= 9.000000 mm | CC= 2.89m SSL | ZP150/918 |  | Dra.no: 2 | 4 | 0.2 m\X\B3/h | Storey: 3 | Edge= 2.88m SSL |  | 2413 | NN=6.19 m | .000 |  | Top= 0.00m FCL | 0.000000 | Circulation | 0.32 m/s | Circulation

# IfcFlowFitting: CH3000022015, 1.25.0
In: 00 Ground floor
Type - Description: Cu fitting reducer 22/15; ApplicableOccurrence: Basic; PredefinedType: TRANSITION
Type - Pset_ManufacturerTypeInformation - ArticleNumber: CH3000022015; ModelReference: Cu fitting reducer 22/15; Manufacturer: DDS
Type - Pset_PipeFittingTypeCommon - NominalDiameter: 20, 12; InnerDiameter: 20, 13; OuterDiameter: 22, 15
Material: IFC Building Material; Group: Coldwater
Pset_DDS - Mounting Height: 3.10 m; X: X=21.92; Velocity: 2.24 m/s; Pipe thickness:: x1.0; Dimension DN: 20 mm; Mtg. Below Ceiling ref Center: CC= 0.40m FCL; Main string number: 01; Above Sea Level ref. Bottom: NNUK=2.88 m; Mtg. above Finished Floor ref Center: CC= 3.10m FFB; Manufacturer: DDS; Ins thickness: ins= 9.000000 mm; Mtg. Above Slab ref Center: CC= 3.10m SSL; Y: Y=10.94; System Name: PW; Model Number: Dra.no: 1; Product Number: CH3000022015; Layer number: 2; Width: 20; Sub string number: .0025; Flow (l/s): 0.39 l/s; Project name: OpenBIM; Flow (l/h): 1403.999949 l/h; Height: 0; Insulation k-value: 0; Insulation WSVO: 0; Outside dimension: 22.000000; Flow (m\X\B3/h): 1.4 m\X\B3/h; Floor number: Storey: 2; Mtg. Above Slab ref Bottom: Edge= 3.09m SSL; Above Sea Level ref. Center: NN=2.90 m; Product: Cu fitting reducer 22/15; Room tekst: Entrance; Length: 10.0 m; Part number: .000; Insulation product text: Pipe insulation; Room number: 00.01; Rotation: 0.000000; Pressure drop: 25583; Mtg. Below Ceiling ref Top: Top= 0.39m FCL; Building Part: Building: 0; Medium: Coldwater; Abs. pressure: 0.0 Pa; Insulation product number: ZP150/922
AC_Pset_RenovationAndPhasing - Renovation Status: Existing

# IfcFlowFitting: CH3000022018 (3)
In: 00 Ground floor
Type - Description: Cu fitting reducer 22/18; ApplicableOccurrence: Basic; PredefinedType: TRANSITION
Type - Pset_ManufacturerTypeInformation - ArticleNumber: CH3000022018; ModelReference: Cu fitting reducer 22/18; Manufacturer: DDS
Type - Pset_PipeFittingTypeCommon - NominalDiameter: 20, 15; InnerDiameter: 20, 16; OuterDiameter: 22, 18
Material: IFC Building Material
Pset_DDS - Pipe thickness:: x1.0; Dimension DN: 20 mm; Manufacturer: DDS; Product Number: CH3000022018; Model Number: Dra.no: 1; Width: 20; Project name: OpenBIM; Height: 0; Insulation k-value: 0; Insulation WSVO: 0; Outside dimension: 22.000000; Floor number: Storey: 2; Product: Cu fitting reducer 22/18; Length: 10.0 m; Part number: .000; Sub string number: .0002; Rotation: 0.000000; Building Part: Building: 0; Abs. pressure: 0.0 Pa
AC_Pset_RenovationAndPhasing - Renovation Status: Existing
Name | Flow (l/h) | Mtg. Above Slab ref Bottom | Main string number | Mtg. Above Slab ref Center | Ins thickness | Mtg. Below Ceiling ref Top | Pressure drop | Y | X | Mtg. Below Ceiling ref Center | System Name | Layer number | Velocity | Mounting Height | Room number | Room tekst | Flow (m\X\B3/h) | Above Sea Level ref. Center | Flow (l/s) | Mtg. above Finished Floor ref Center | Above Sea Level ref. Bottom | Medium | Group
1.2.0 | 3131.999937 l/h | Edge= 3.02m SSL | 01 | CC= 3.03m SSL | ins= 9.000000 mm | Top= 0.26m FCL | 16914 | Y=10.94 | X=29.36 | CC= 0.27m FCL | PW | 2 | 2.49 m/s | 3.16 m | 00.27 | Shaft | 3.1 m\X\B3/h | NN=2.96 m | 0.87 l/s | CC= 3.03m FFB | NNUK=2.94 m | Coldwater | Coldwater | Pset_DDS - Insulation product text: Pipe insulation; Insulation product number: ZP150/922
2.2.0 | 0.000000 l/h | Edge= 2.79m SSL | 02 | CC= 2.80m SSL | ins= 0.000000 mm | Top= 0.49m FCL | 0 | Y=16.89 | X=32.17 | CC= 0.50m FCL | Cooling | 188 | 0.00 m/s | 2.80 m | 00.03 | Hallway | 0.0 m\X\B3/h | NN=2.60 m | 0.00 l/s | CC= 2.80m FFB | NNUK=2.58 m | Cooling Flow | Cooling flow
3.2.0 | 0.000000 l/h | Edge= 2.79m SSL | 03 | CC= 2.80m SSL | ins= 0.000000 mm | Top= 0.49m FCL | 0 | Y=16.82 | X=32.23 | CC= 0.50m FCL | Cooling | 189 | 0.00 m/s | 2.80 m | 00.03 | Hallway | 0.0 m\X\B3/h | NN=2.60 m | 0.00 l/s | CC= 2.80m FFB | NNUK=2.58 m | Cooling return | Cooling return

# IfcFlowFitting: CH3000035022 (4)
In: 00 Ground floor
Type - Description: Cu fitting reducer 35/22; ApplicableOccurrence: Basic; PredefinedType: TRANSITION
Type - Pset_ManufacturerTypeInformation - ArticleNumber: CH3000035022; ModelReference: Cu fitting reducer 35/22; Manufacturer: DDS
Type - Pset_PipeFittingTypeCommon - NominalDiameter: 32, 20; InnerDiameter: 32, 20; OuterDiameter: 35, 22
Material: IFC Building Material
Pset_DDS - Product: Cu fitting reducer 35/22; Manufacturer: DDS; Width: 32; Ins thickness: ins= 0.000000 mm; Product Number: CH3000035022; Dimension DN: 32 mm; Model Number: Dra.no: 1; Length: 16.0 m; Project name: OpenBIM; Height: 0; Insulation k-value: 0; Pressure drop: 0; Insulation WSVO: 0; Flow (m\X\B3/h): 0.0 m\X\B3/h; Floor number: Storey: 2; Flow (l/h): 0.000000 l/h; Part number: .000; Outside dimension: 35.000000; Rotation: 0.000000; Building Part: Building: 0; Flow (l/s): 0.00 l/s; Pipe thickness:: x1.5; Abs. pressure: 0.0 Pa; Velocity: 0.00 m/s
AC_Pset_RenovationAndPhasing - Renovation Status: Existing
Name | X | Mounting Height | Mtg. Below Ceiling ref Center | Mtg. Above Slab ref Bottom | Mtg. above Finished Floor ref Center | Main string number | Mtg. Above Slab ref Center | Layer number | Above Sea Level ref. Center | Y | Above Sea Level ref. Bottom | Sub string number | Medium | Mtg. Below Ceiling ref Top
2.1.0 | X=30.84 | 2.80 m | CC= 0.70m FCL | Edge= 2.78m SSL | CC= 2.80m FFB | 02 | CC= 2.80m SSL | 188 | NN=2.60 m | Y=13.25 | NNUK=2.57 m | .0001 | Cooling Flow | Top= 0.00m FCL | Pset_DDS - System Name: Cooling; Group: Cooling flow
3.1.0 | X=30.84 | 2.80 m | CC= 0.70m FCL | Edge= 2.78m SSL | CC= 2.80m FFB | 03 | CC= 2.80m SSL | 189 | NN=2.60 m | Y=13.18 | NNUK=2.57 m | .0001 | Cooling return | Top= 0.00m FCL | Pset_DDS - System Name: Cooling; Group: Cooling return
Transition | X=29.28 | -0.20 m | CC= 3.63m FCL | Edge= -0.35m SSL | CC= -0.33m FFB | 00 | CC= -0.33m SSL | 5 | NN=-0.40 m | Y=11.94 | NNUK=-0.43 m | .0000 | Heat flow | Top= 3.61m FCL | Pset_DDS - Room number: 00.27; Room tekst: Shaft
Transition | X=29.28 | -0.10 m | CC= 3.53m FCL | Edge= -0.25m SSL | CC= -0.23m FFB | 00 | CC= -0.23m SSL | 6 | NN=-0.30 m | Y=11.83 | NNUK=-0.33 m | .0000 | Heat return | Top= 3.51m FCL | Pset_DDS - Room number: 00.27; Room tekst: Shaft

# IfcFlowFitting: CH3000042035 (2)
In: 02 Second floor
Type - Description: Cu fitting reducer 42/35; ApplicableOccurrence: Basic; PredefinedType: TRANSITION
Type - Pset_ManufacturerTypeInformation - ArticleNumber: CH3000042035; ModelReference: Cu fitting reducer 42/35; Manufacturer: DDS
Type - Pset_PipeFittingTypeCommon - NominalDiameter: 32, 40; InnerDiameter: 32, 39; OuterDiameter: 35, 42
Material: IFC Building Material
Pset_DDS - Manufacturer: DDS; Width: 32; Ins thickness: ins= 9.000000 mm; Room tekst: Installation space; Insulation product text: Pipe insulation; Dimension DN: 32 mm; Model Number: Dra.no: 3; Main string number: 00; Project name: OpenBIM; Height: 0; Insulation k-value: 0; Pressure drop: 0; Insulation WSVO: 0; Flow (m\X\B3/h): 0.0 m\X\B3/h; Floor number: Storey: 4; Insulation product number: ZP150/935; Flow (l/h): 0.000000 l/h; Length: 20.0 m; Product: Cu fitting reducer 42/35; Part number: .000; Outside dimension: 35.000000; Sub string number: .0000; Room number: 02.04; Rotation: 0.000000; Product Number: CH3000042035; Building Part: Building: 0; Flow (l/s): 0.00 l/s; Pipe thickness:: x1.5; Abs. pressure: 0.0 Pa; Velocity: 0.00 m/s
AC_Pset_RenovationAndPhasing - Renovation Status: Existing
Name | Mtg. Above Slab ref Bottom | Mounting Height | Above Sea Level ref. Center | Mtg. Below Ceiling ref Center | Y | Mtg. above Finished Floor ref Center | Mtg. Above Slab ref Center | Mtg. Below Ceiling ref Top | Layer number | Above Sea Level ref. Bottom | Medium | X
Transition | Edge= -0.05m SSL | 0.10 m | NN=6.90 m | CC= 3.33m FCL | Y=12.85 | CC= -0.03m FFB | CC= -0.03m SSL | Top= 3.31m FCL | 6 | NNUK=6.87 m | Heat return | X=8.03
Transition | Edge= 0.05m SSL | 0.20 m | NN=7.00 m | CC= 3.23m FCL | Y=12.75 | CC= 0.07m FFB | CC= 0.07m SSL | Top= 3.21m FCL | 5 | NNUK=6.97 m | Heat flow | X=8.27

# IfcFlowFitting: CH3000054042 (2)
In: 02 Second floor
Type - Description: Cu fitting reducer 54/42; ApplicableOccurrence: Basic; PredefinedType: TRANSITION
Type - Pset_ManufacturerTypeInformation - ArticleNumber: CH3000054042; ModelReference: Cu fitting reducer 54/42; Manufacturer: DDS
Type - Pset_PipeFittingTypeCommon - NominalDiameter: 40, 50; InnerDiameter: 39, 50; OuterDiameter: 42, 54
Material: IFC Building Material
Pset_DDS - Dimension DN: 40 mm; Length: 25.0 m; Manufacturer: DDS; Insulation product number: ZP150/948; Ins thickness: ins= 9.000000 mm; Room tekst: Installation space; Product Number: CH3000054042; Model Number: Dra.no: 3; Width: 40; Main string number: 00; Project name: OpenBIM; Height: 0; Insulation k-value: 0; Pressure drop: 0; Insulation WSVO: 0; Insulation product text: Pipe insulation; Outside dimension: 42.000000; Flow (m\X\B3/h): 0.0 m\X\B3/h; Floor number: Storey: 4; Flow (l/h): 0.000000 l/h; Product: Cu fitting reducer 54/42; Part number: .000; Sub string number: .0000; Room number: 02.04; Rotation: 0.000000; Building Part: Building: 0; Flow (l/s): 0.00 l/s; Pipe thickness:: x1.5; Abs. pressure: 0.0 Pa; Velocity: 0.00 m/s
AC_Pset_RenovationAndPhasing - Renovation Status: Existing
Name | Mtg. Above Slab ref Bottom | Mounting Height | Above Sea Level ref. Center | Mtg. Below Ceiling ref Center | Mtg. above Finished Floor ref Center | Mtg. Above Slab ref Center | Mtg. Below Ceiling ref Top | Layer number | Above Sea Level ref. Bottom | Y | Medium | X
Transition | Edge= -0.05m SSL | 0.10 m | NN=6.90 m | CC= 3.33m FCL | CC= -0.03m FFB | CC= -0.03m SSL | Top= 3.31m FCL | 6 | NNUK=6.86 m | Y=13.48 | Heat return | X=8.03
Transition | Edge= 0.05m SSL | 0.20 m | NN=7.00 m | CC= 3.23m FCL | CC= 0.07m FFB | CC= 0.07m SSL | Top= 3.21m FCL | 5 | NNUK=6.96 m | Y=13.37 | Heat flow | X=8.27

# IfcFlowFitting: CH5100100050 (2)
Type - Description: HT reducer 100/50; ApplicableOccurrence: Basic; PredefinedType: TRANSITION
Type - Pset_ManufacturerTypeInformation - ArticleNumber: CH5100100050; ModelReference: HT reducer 100/50; Manufacturer: DDS
Type - Pset_PipeFittingTypeCommon - NominalDiameter: 100, 50; InnerDiameter: 104.6, 46.4; OuterDiameter: 110, 50
Material: IFC Building Material
Pset_DDS - Mtg. above Finished Floor ref Center: CC= -0.09m FFB; Medium: Sewer; Product Number: CH5100100050; Manufacturer: DDS; Pipe thickness:: x2.7; Dimension DN: 100 mm; Mtg. Above Slab ref Center: CC= -0.09m SSL; Product: HT reducer 100/50; X: X=22.25; Ins thickness: ins= 0.000000 mm; Outside dimension: 109.999999; Y: Y=15.04; Layer number: 178; Mtg. Above Slab ref Bottom: Edge= -0.14m SSL; Main string number: 00; Width: 100; Project name: OpenBIM; Height: 0; Insulation k-value: 0; Pressure drop: 0; Insulation WSVO: 0; Flow (m\X\B3/h): 0.0 m\X\B3/h; Flow (l/h): 0.000000 l/h; Length: 50.0 m; Mounting Height: -0.09 m; Part number: .000; Sub string number: .0000; Rotation: 0.000000; Building Part: Building: 0; Mtg. Below Ceiling ref Top: Top= 0.00m FCL; Flow (l/s): 0.00 l/s; Abs. pressure: 0.0 Pa; Velocity: 0.00 m/s
AC_Pset_RenovationAndPhasing - Renovation Status: Existing
Name | In | Model Number | Floor number | Mtg. Below Ceiling ref Center | Above Sea Level ref. Bottom | Above Sea Level ref. Center
Transition | 00 Ground floor | Dra.no: 1 | Storey: 2 | CC= 3.59m FCL | NNUK=-0.39 m | NN=-0.29 m
Transition | 01 First floor | Dra.no: 2 | Storey: 3 | CC= 3.39m FCL | NNUK=3.11 m | NN=3.21 m

# IfcFlowFitting: CH5100xxx (2)
In: 01 First floor
Type - Description: HT reducer free; ApplicableOccurrence: Basic; PredefinedType: TRANSITION
Type - Pset_ManufacturerTypeInformation - ArticleNumber: CH5100xxx; ModelReference: HT reducer free; Manufacturer: DDS
Type - Pset_PipeFittingTypeCommon - NominalDiameter: 20, 15; InnerDiameter: 20, 15; OuterDiameter: 22, 15
Material: IFC Building Material
Pset_DDS - Pipe thickness:: x1.0; Dimension DN: 20 mm; Product Number: CH5100xxx; Manufacturer: DDS; Ins thickness: ins= 0.000000 mm; Room tekst: Office; Room number: 01.17; Model Number: Dra.no: 2; Width: 20; Main string number: 00; Project name: OpenBIM; Height: 0; Insulation k-value: 0; Pressure drop: 0; Insulation WSVO: 0; Outside dimension: 22.000000; Flow (m\X\B3/h): 0.0 m\X\B3/h; Floor number: Storey: 3; Flow (l/h): 0.000000 l/h; Length: 10.0 m; Part number: .000; Sub string number: .0000; Product: HT reducer free; Rotation: 0.000000; Building Part: Building: 0; Flow (l/s): 0.00 l/s; Abs. pressure: 0.0 Pa; Velocity: 0.00 m/s
AC_Pset_RenovationAndPhasing - Renovation Status: Existing
Name | Mounting Height | Mtg. Below Ceiling ref Center | Above Sea Level ref. Center | Medium | X | Mtg. Below Ceiling ref Top | Y | Mtg. Above Slab ref Bottom | Mtg. Above Slab ref Center | Layer number | Mtg. above Finished Floor ref Center | Above Sea Level ref. Bottom
Transition | -0.10 m | CC= 3.53m FCL | NN=3.20 m | Heat flow | X=5.48 | Top= 3.52m FCL | Y=12.22 | Edge= -0.24m SSL | CC= -0.23m SSL | 5 | CC= -0.23m FFB | NNUK=3.18 m
Transition | -0.20 m | CC= 3.63m FCL | NN=3.10 m | Heat return | X=5.62 | Top= 3.62m FCL | Y=12.27 | Edge= -0.34m SSL | CC= -0.33m SSL | 6 | CC= -0.33m FFB | NNUK=3.08 m

# IfcFlowFitting: CH8300140125 (2)
In: 00 Ground floor
Type - Description: Reducer Folded Spiral-seam Circ d 140/125 symetric; PredefinedType: TRANSITION
Type - Pset_ManufacturerTypeInformation - ArticleNumber: CH8300140125; ModelReference: Reducer Folded Spiral-seam Circ d 140/125 symetric; Manufacturer: DDS
Type - Pset_DuctFittingTypeCommon - NominalDiameterOrWidth: 140, 125; NominalHeight: 140, 125
Material: IFC Building Material
Pset_DDS - Above Sea Level ref. Bottom: NNUK=2.66 m; Mounting Height: 3.00 m; Width: 140; Above Sea Level ref. Center: NN=2.80 m; Length: 45.0 m; Sub string number: .0031; Manufacturer: DDS; Ins thickness: ins= 0.000000 mm; Model Number: Dra.no: 1; Outside dimension: 140.000000; Project name: OpenBIM; Height: 0; Insulation k-value: 0; Pressure drop: 0; Insulation WSVO: 0; Floor number: Storey: 2; Pipe thickness:: x0.0; Dimension DN: 140 mm; Rotation: 0.000000; Product: Reducer Folded Spiral-seam Circ d 140/125 symetric; Building Part: Building: 0; Product Number: CH8300140125
AC_Pset_RenovationAndPhasing - Renovation Status: Existing
Name | Mtg. Below Ceiling ref Center | Abs. pressure | Velocity | Main string number | X | Y | Flow (m\X\B3/h) | Mtg. above Finished Floor ref Center | Medium | Part number | Layer number | Room number | Mtg. Above Slab ref Center | Room tekst | Mtg. Above Slab ref Bottom | Flow (l/s) | Flow (l/h) | Mtg. Below Ceiling ref Top
1.31.2 | CC= 0.43m FCL | 248.8 Pa | 2.26 m/s | 01 | X=35.24 | Y=9.28 | 100.0 m\X\B3/h | CC= 2.87m FFB | Supply Air | .002 | 10 | 00.25 | CC= 2.87m SSL | Director office | Edge= 2.80m SSL | 27.78 l/s | 100000.000000 l/h | Top= 0.36m FCL | Pset_DDS - System Name: Supply Air; Group: Supply air
Transition | CC= 0.30m FCL | 0.0 Pa | 0.00 m/s | 00 | X=23.79 | Y=13.30 | 0.0 m\X\B3/h | CC= 3.00m FFB | Extract Air | .000 | 11 | 00.03 | CC= 3.00m SSL | Hallway | Edge= 2.93m SSL | 0.00 l/s | 0.000000 l/h | Top= 0.23m FCL

# IfcFlowFitting: CH8300160140 (2)
In: 00 Ground floor
Type - Description: Reducer Folded Spiral-seam Circ d 160/140 symetric; PredefinedType: TRANSITION
Type - Pset_ManufacturerTypeInformation - ArticleNumber: CH8300160140; ModelReference: Reducer Folded Spiral-seam Circ d 160/140 symetric; Manufacturer: DDS
Type - Pset_DuctFittingTypeCommon - NominalDiameterOrWidth: 160, 140; NominalHeight: 160, 140
Material: IFC Building Material
Pset_DDS - Dimension DN: 160 mm; Above Sea Level ref. Bottom: NNUK=2.64 m; Mounting Height: 3.00 m; Above Sea Level ref. Center: NN=2.80 m; Length: 45.0 m; Manufacturer: DDS; Ins thickness: ins= 0.000000 mm; Model Number: Dra.no: 1; Project name: OpenBIM; Height: 0; Insulation k-value: 0; Pressure drop: 0; Insulation WSVO: 0; Outside dimension: 160.000000; Floor number: Storey: 2; Product Number: CH8300160140; Pipe thickness:: x0.0; Width: 160; Rotation: 0.000000; Building Part: Building: 0; Product: Reducer Folded Spiral-seam Circ d 160/140 symetric
AC_Pset_RenovationAndPhasing - Renovation Status: Existing
Name | Mtg. Below Ceiling ref Center | Main string number | Sub string number | Y | X | Flow (m\X\B3/h) | Mtg. above Finished Floor ref Center | Medium | Flow (l/s) | Part number | Layer number | Room number | Flow (l/h) | Mtg. Above Slab ref Center | Mtg. Above Slab ref Bottom | Velocity | Abs. pressure | Room tekst | Mtg. Below Ceiling ref Top
1.30.2 | CC= 0.43m FCL | 01 | .0030 | Y=9.28 | X=33.36 | 200.0 m\X\B3/h | CC= 2.87m FFB | Supply Air | 55.56 l/s | .002 | 10 | 00.25 | 200000.000000 l/h | CC= 2.87m SSL | Edge= 2.79m SSL | 3.61 m/s | 252.1 Pa | Director office | Top= 0.35m FCL | Pset_DDS - System Name: Supply Air; Group: Supply air
Transition | CC= 0.30m FCL | 00 | .0031 | Y=12.88 | X=20.21 | 0.0 m\X\B3/h | CC= 3.00m FFB | Extract Air | 0.00 l/s | .000 | 11 | 00.04 | 0.000000 l/h | CC= 3.00m SSL | Edge= 2.92m SSL | 0.00 m/s | 0.0 Pa | corridor | Top= 0.22m FCL

# IfcFlowFitting: CH8300200160, Transition
In: 00 Ground floor
Type - Description: Reducer Folded Spiral-seam Circ d 200/160 symetric; PredefinedType: TRANSITION
Type - Pset_ManufacturerTypeInformation - ArticleNumber: CH8300200160; ModelReference: Reducer Folded Spiral-seam Circ d 200/160 symetric; Manufacturer: DDS
Type - Pset_DuctFittingTypeCommon - NominalDiameterOrWidth: 200, 160; NominalHeight: 200, 160
Material: IFC Building Material
Pset_DDS - Y: Y=13.17; Above Sea Level ref. Bottom: NNUK=2.60 m; Mounting Height: 3.00 m; Above Sea Level ref. Center: NN=2.80 m; Length: 45.0 m; Mtg. Below Ceiling ref Center: CC= 0.30m FCL; Sub string number: .0031; Product Number: CH8300200160; Mtg. above Finished Floor ref Center: CC= 3.00m FFB; Manufacturer: DDS; Dimension DN: 200 mm; Mtg. Above Slab ref Center: CC= 3.00m SSL; Ins thickness: ins= 0.000000 mm; Mtg. Below Ceiling ref Top: Top= 0.20m FCL; Product: Reducer Folded Spiral-seam Circ d 200/160 symetric; Model Number: Dra.no: 1; Layer number: 11; Main string number: 00; Width: 200; Project name: OpenBIM; Height: 0; Insulation k-value: 0; Pressure drop: 0; Insulation WSVO: 0; Flow (m\X\B3/h): 0.0 m\X\B3/h; Floor number: Storey: 2; Room tekst: corridor; X: X=20.21; Outside dimension: 200.000000; Flow (l/h): 0.000000 l/h; Pipe thickness:: x0.0; Part number: .000; Room number: 00.04; Mtg. Above Slab ref Bottom: Edge= 2.90m SSL; Rotation: 0.000000; Building Part: Building: 0; Flow (l/s): 0.00 l/s; Medium: Extract Air; Abs. pressure: 0.0 Pa; Velocity: 0.00 m/s
AC_Pset_RenovationAndPhasing - Renovation Status: Existing

# IfcFlowFitting: CH8300250200, Transition
In: 00 Ground floor
Type - Description: Reducer Folded Spiral-seam Circ d 250/200 symetric; PredefinedType: TRANSITION
Type - Pset_ManufacturerTypeInformation - ArticleNumber: CH8300250200; ModelReference: Reducer Folded Spiral-seam Circ d 250/200 symetric; Manufacturer: DDS
Type - Pset_DuctFittingTypeCommon - NominalDiameterOrWidth: 250, 200; NominalHeight: 250, 200
Material: IFC Building Material
Pset_DDS - Mounting Height: 3.00 m; Above Sea Level ref. Center: NN=2.80 m; Y: Y=13.67; Mtg. Below Ceiling ref Center: CC= 0.30m FCL; Outside dimension: 250.000000; Sub string number: .0031; Mtg. Above Slab ref Bottom: Edge= 2.88m SSL; Mtg. above Finished Floor ref Center: CC= 3.00m FFB; Manufacturer: DDS; Product Number: CH8300250200; Mtg. Above Slab ref Center: CC= 3.00m SSL; Ins thickness: ins= 0.000000 mm; Model Number: Dra.no: 1; Layer number: 11; Main string number: 00; Project name: OpenBIM; Height: 0; Insulation k-value: 0; Pressure drop: 0; Insulation WSVO: 0; Flow (m\X\B3/h): 0.0 m\X\B3/h; Dimension DN: 250 mm; Floor number: Storey: 2; Room tekst: corridor; X: X=20.21; Width: 250; Flow (l/h): 0.000000 l/h; Length: 70.0 m; Pipe thickness:: x0.0; Part number: .000; Above Sea Level ref. Bottom: NNUK=2.55 m; Room number: 00.04; Mtg. Below Ceiling ref Top: Top= 0.17m FCL; Rotation: 0.000000; Building Part: Building: 0; Flow (l/s): 0.00 l/s; Medium: Extract Air; Abs. pressure: 0.0 Pa; Velocity: 0.00 m/s; Product: Reducer Folded Spiral-seam Circ d 250/200 symetric
AC_Pset_RenovationAndPhasing - Renovation Status: Existing

# IfcFlowFitting: GT004, 1.3.4
In: 00 Ground floor
Type - Description: Tee Part; ApplicableOccurrence: Duct; PredefinedType: JUNCTION
Type - Pset_ManufacturerTypeInformation - ArticleNumber: GT004; ModelReference: Tee Part; Manufacturer: DDS; ModelLabel: GT
Type - Pset_DuctFittingTypeCommon - NominalDiameterOrWidth: 300, 300, 200; NominalHeight: 300, 300, 300
Material: IFC Building Material; Group: Supply air
Pset_DDS - Mounting Height: 3.00 m; Above Sea Level ref. Center: NN=2.80 m; Flow (l/s): 731.11 l/s; Dimension I: 0mm; Mtg. Below Ceiling ref Center: CC= 0.30m FCL; Rotation: 180.000000; Main string number: 01; Product Number: GT004; Product: Tee Part; Mtg. above Finished Floor ref Center: CC= 3.00m FFB; Manufacturer: DDS; Mtg. Above Slab ref Center: CC= 3.00m SSL; Ins thickness: ins= 0.000000 mm; Part number: .004; System Name: Supply Air; Medium: Supply Air; Pipe thickness:: x1.1; X: X=32.41; Model Number: Dra.no: 1; Layer number: 10; Dimension E: 200; Dimension B: 300; Dimension A: 300; Tee dimension height: 300; Tee dimension: 300; Dimension F: 400; Dimension R: 100; Height: 300; Width: 300; Project name: OpenBIM; Dimension M: 0; Insulation k-value: 0; Pressure drop: 0; Insulation WSVO: 0; Abs. pressure: 208.5 Pa; Flow (m\X\B3/h): 2632.0 m\X\B3/h; Floor number: Storey: 2; Length: 1200.0 m; Room tekst: Hallway; Mtg. Above Slab ref Bottom: Edge= 2.85m SSL; Outside dimension: 300.000000; Y: Y=18.32; Above Sea Level ref. Bottom: NNUK=2.50 m; Sub string number: .0003; Room number: 00.03; Dimension DN: 300 x 300 mm; Dimension L: 1200; Mtg. Below Ceiling ref Top: Top= 0.15m FCL; Velocity: 10.19 m/s; Building Part: Building: 0; Flow (l/h): 2632000.000000 l/h
AC_Pset_RenovationAndPhasing - Renovation Status: Existing

# IfcFlowFitting: GT004, 1.2.6
In: 00 Ground floor
Type - Description: Tee Part; ApplicableOccurrence: Duct; PredefinedType: JUNCTION
Type - Pset_ManufacturerTypeInformation - ArticleNumber: GT004; ModelReference: Tee Part; Manufacturer: DDS; ModelLabel: GT
Type - Pset_DuctFittingTypeCommon - NominalDiameterOrWidth: 400, 600, 300; NominalHeight: 300, 300, 300
Material: IFC Building Material; Group: Supply air
Pset_DDS - Part number: .006; Mounting Height: 3.00 m; Velocity: 8.12 m/s; Above Sea Level ref. Center: NN=2.80 m; Y: Y=12.83; Dimension I: 0mm; Mtg. Below Ceiling ref Center: CC= 0.30m FCL; Rotation: 180.000000; Main string number: 01; Product Number: GT004; Product: Tee Part; Mtg. above Finished Floor ref Center: CC= 3.00m FFB; Manufacturer: DDS; Flow (m\X\B3/h): 3482.0 m\X\B3/h; Mtg. Above Slab ref Center: CC= 3.00m SSL; Ins thickness: ins= 0.000000 mm; System Name: Supply Air; Medium: Supply Air; Pipe thickness:: x1.1; X: X=32.41; Model Number: Dra.no: 1; Layer number: 10; Dimension E: 200; Dimension A: 300; Tee dimension height: 300; Dimension F: 400; Dimension B: 400; Tee dimension: 600; Dimension R: 100; Height: 300; Width: 600; Project name: OpenBIM; Dimension M: 0; Insulation k-value: 0; Pressure drop: 0; Insulation WSVO: 0; Floor number: Storey: 2; Length: 1200.0 m; Room tekst: Hallway; Mtg. Above Slab ref Bottom: Edge= 2.85m SSL; Abs. pressure: 263.4 Pa; Outside dimension: 600.000000; Dimension DN: 600 x 300 mm; Above Sea Level ref. Bottom: NNUK=2.50 m; Sub string number: .0002; Room number: 00.03; Flow (l/h): 3482000.000000 l/h; Dimension L: 1200; Mtg. Below Ceiling ref Top: Top= 0.15m FCL; Flow (l/s): 967.22 l/s; Building Part: Building: 0
AC_Pset_RenovationAndPhasing - Renovation Status: Existing

# IfcFlowFitting: GT004, 1.1.20
In: 01 First floor
Type - Description: Tee Part; ApplicableOccurrence: Duct; PredefinedType: JUNCTION
Type - Pset_ManufacturerTypeInformation - ArticleNumber: GT004; ModelReference: Tee Part; Manufacturer: DDS; ModelLabel: GT
Type - Pset_DuctFittingTypeCommon - NominalDiameterOrWidth: 600, 300, 600; NominalHeight: 600, 600, 600
Material: IFC Building Material; Group: Supply air
Pset_DDS - Mounting Height: 3.00 m; Flow (l/s): 1356.11 l/s; Y: Y=12.83; Dimension I: 0mm; Mtg. Below Ceiling ref Center: CC= 0.30m FCL; X: X=30.60; Main string number: 01; Product Number: GT004; Product: Tee Part; Mtg. above Finished Floor ref Center: CC= 3.00m FFB; Manufacturer: DDS; Rotation: 270.000000; Mtg. Above Slab ref Center: CC= 3.00m SSL; Ins thickness: ins= 0.000000 mm; System Name: Supply Air; Above Sea Level ref. Center: NN=6.30 m; Medium: Supply Air; Pipe thickness:: x1.1; Length: 800.0 m; Model Number: Dra.no: 2; Layer number: 10; Velocity: 2.69 m/s; Tee dimension: 300; Dimension L: 800; Dimension F: 400; Dimension A: 600; Dimension B: 600; Tee dimension height: 600; Dimension R: 100; Width: 600; Height: 600; Project name: OpenBIM; Dimension M: 0; Insulation k-value: 0; Pressure drop: 0; Insulation WSVO: 0; Abs. pressure: 301.1 Pa; Floor number: Storey: 3; Dimension E: 150; Outside dimension: 600.000000; Part number: .020; Dimension DN: 600 x 600 mm; Sub string number: .0001; Flow (m\X\B3/h): 4882.0 m\X\B3/h; Mtg. Above Slab ref Bottom: Edge= 2.70m SSL; Above Sea Level ref. Bottom: NNUK=5.70 m; Flow (l/h): 4882000.000000 l/h; Building Part: Building: 0; Mtg. Below Ceiling ref Top: Top= 0.00m FCL
AC_Pset_RenovationAndPhasing - Renovation Status: Existing

# IfcFlowFitting: Gas25_10_1, Meter
In: 00 Ground floor
Type - Description: Gas meter 1 connection 10 DN 25; ApplicableOccurrence: Basic
Type - Pset_ManufacturerTypeInformation - ArticleNumber: Gas25_10_1; ModelReference: Gas meter 1 connection 10 DN 25; Manufacturer: DDS
Material: IFC Building Material
Pset_DDS - Mounting Height: 0.50 m; Product: Gas meter 1 connection 10 DN 25; Above Sea Level ref. Center: NN=0.30 m; Mtg. Below Ceiling ref Center: CC= 2.93m FCL; Y: Y=10.62; Manufacturer: DDS; Ins thickness: ins= 0.000000 mm; Room tekst: FB; Mtg. above Finished Floor ref Center: CC= 0.37m FFB; Outside dimension: 28.000000; Length: 250.0 m; Room number: 00.15; Model Number: Dra.no: 1; Mtg. Above Slab ref Bottom: Edge= 0.36m SSL; Layer number: 198; Main string number: 00; Project name: OpenBIM; Height: 0; Insulation k-value: 0; Pressure drop: 0; Insulation WSVO: 0; Mtg. Above Slab ref Center: CC= 0.37m SSL; Flow (m\X\B3/h): 0.0 m\X\B3/h; Floor number: Storey: 2; Width: 25; Medium: Gas middle pressure; Flow (l/h): 0.000000 l/h; Mtg. Below Ceiling ref Top: Top= 2.92m FCL; Part number: .000; X: X=30.59; Sub string number: .0000; Above Sea Level ref. Bottom: NNUK=0.28 m; Rotation: 0.000000; Dimension DN: 25 mm; Building Part: Building: 0; Flow (l/s): 0.00 l/s; Product Number: Gas25_10_1; Pipe thickness:: x1.5; Abs. pressure: 0.0 Pa; Velocity: 0.00 m/s
AC_Pset_RenovationAndPhasing - Renovation Status: Existing

# IfcFlowFitting: LI-20111028-001, 1.0.11
In: 00 Ground floor
Type - Description: End cap angled; ApplicableOccurrence: Duct; PredefinedType: OBSTRUCTION
Type - Pset_ManufacturerTypeInformation - ArticleNumber: LI-20111028-001; ModelReference: End cap angled; Manufacturer: DDS
Type - Pset_DuctFittingTypeCommon - NominalDiameterOrWidth: 315
Material: IFC Building Material; Group: Supply air
Pset_DDS - Dimension DN: 315 mm; Mounting Height: 3.00 m; Above Sea Level ref. Center: NN=2.80 m; Above Sea Level ref. Bottom: NNUK=2.49 m; Mtg. Below Ceiling ref Center: CC= 0.30m FCL; Main string number: 01; Width: 315; Mtg. Above Slab ref Bottom: Edge= 2.84m SSL; X: X=9.28; Mtg. above Finished Floor ref Center: CC= 3.00m FFB; Manufacturer: DDS; Mtg. Above Slab ref Center: CC= 3.00m SSL; Ins thickness: ins= 0.000000 mm; Length: 1.0 m; System Name: Supply Air; Product: End cap angled; Part number: .011; Medium: Supply Air; Y: Y=18.25; Room tekst: Office; Model Number: Dra.no: 1; Layer number: 10; Room number: 00.20; Project name: OpenBIM; Height: 0; Insulation k-value: 0; Pressure drop: 0; Insulation WSVO: 0; Flow (m\X\B3/h): 0.0 m\X\B3/h; Floor number: Storey: 2; Flow (l/h): 0.000000 l/h; Pipe thickness:: x0.0; Sub string number: .0000; Mtg. Below Ceiling ref Top: Top= 0.14m FCL; Outside dimension: 0.000000; Rotation: 0.000000; Building Part: Building: 0; Flow (l/s): 0.00 l/s; Product Number: LI-20111028-001; Abs. pressure: 0.0 Pa; Velocity: 0.00 m/s
AC_Pset_RenovationAndPhasing - Renovation Status: Existing

# IfcFlowFitting: LI-20111028-001, 1.0.21
In: 00 Ground floor
Type - Description: End cap angled; ApplicableOccurrence: Duct; PredefinedType: OBSTRUCTION
Type - Pset_ManufacturerTypeInformation - ArticleNumber: LI-20111028-001; ModelReference: End cap angled; Manufacturer: DDS
Type - Pset_DuctFittingTypeCommon - NominalDiameterOrWidth: 400; NominalHeight: 200
Material: IFC Building Material; Group: Supply air
Pset_DDS - Main string number: 01; Manufacturer: DDS; Mounting Height: 3.15 m; Ins thickness: ins= 0.000000 mm; Length: 1.0 m; Mtg. Below Ceiling ref Top: Top= 0.25m FCL; System Name: Supply Air; Product: End cap angled; Part number: .021; Medium: Supply Air; Model Number: Dra.no: 1; Layer number: 10; Height: 200; Width: 400; Project name: OpenBIM; Insulation k-value: 0; Pressure drop: 0; Insulation WSVO: 0; Flow (m\X\B3/h): 0.0 m\X\B3/h; Floor number: Storey: 2; Mtg. above Finished Floor ref Center: CC= 3.15m FFB; Mtg. Above Slab ref Bottom: Edge= 3.05m SSL; Above Sea Level ref. Center: NN=2.95 m; Mtg. Below Ceiling ref Center: CC= 0.35m FCL; Above Sea Level ref. Bottom: NNUK=2.75 m; Flow (l/h): 0.000000 l/h; Room tekst: Entrance; Dimension DN: 400 x 200 mm; Pipe thickness:: x0.0; Sub string number: .0000; Room number: 00.01; X: X=15.34; Y: Y=8.14; Outside dimension: 0.000000; Rotation: 0.000000; Mtg. Above Slab ref Center: CC= 3.15m SSL; Building Part: Building: 0; Flow (l/s): 0.00 l/s; Product Number: LI-20111028-001; Abs. pressure: 0.0 Pa; Velocity: 0.00 m/s
AC_Pset_RenovationAndPhasing - Renovation Status: Existing

# IfcFlowFitting: LI-20111028-001, 1.0.26
In: 01 First floor
Type - Description: End cap angled; ApplicableOccurrence: Duct; PredefinedType: OBSTRUCTION
Type - Pset_ManufacturerTypeInformation - ArticleNumber: LI-20111028-001; ModelReference: End cap angled; Manufacturer: DDS
Type - Pset_DuctFittingTypeCommon - NominalDiameterOrWidth: 600; NominalHeight: 300
Material: IFC Building Material; Group: Supply air
Pset_DDS - Mtg. Above Slab ref Center: CC= 3.12m SSL; Part number: .026; Mounting Height: 3.00 m; Main string number: 01; Manufacturer: DDS; Ins thickness: ins= 0.000000 mm; Above Sea Level ref. Bottom: NNUK=6.00 m; Length: 1.0 m; System Name: Supply Air; Above Sea Level ref. Center: NN=6.30 m; Product: End cap angled; Medium: Supply Air; Mtg. Below Ceiling ref Center: CC= 0.18m FCL; Room tekst: Office; Room number: 01.18; Model Number: Dra.no: 2; Layer number: 10; Height: 300; Width: 600; Project name: OpenBIM; Insulation k-value: 0; Pressure drop: 0; Insulation WSVO: 0; Flow (m\X\B3/h): 0.0 m\X\B3/h; Floor number: Storey: 3; X: X=8.21; Flow (l/h): 0.000000 l/h; Pipe thickness:: x0.0; Dimension DN: 600 x 300 mm; Y: Y=18.31; Sub string number: .0000; Outside dimension: 0.000000; Rotation: 0.000000; Building Part: Building: 0; Mtg. above Finished Floor ref Center: CC= 3.12m FFB; Mtg. Below Ceiling ref Top: Top= 0.03m FCL; Flow (l/s): 0.00 l/s; Product Number: LI-20111028-001; Mtg. Above Slab ref Bottom: Edge= 2.97m SSL; Abs. pressure: 0.0 Pa; Velocity: 0.00 m/s
AC_Pset_RenovationAndPhasing - Renovation Status: Existing

# IfcFlowFitting: LI-20130102-010 (2)
In: 03. Roof
Type - Description: PE end fitting DN 110; ApplicableOccurrence: Lid
Type - Pset_ManufacturerTypeInformation - ArticleNumber: LI-20130102-010; ModelReference: PE end fitting DN 110; Manufacturer: DDS; ModelLabel: E1
Material: IFC Building Material
Pset_DDS - Mtg. Above Slab ref Center: CC= -0.15m SSL; Mounting Height: -0.15 m; Above Sea Level ref. Center: NN=10.15 m; Manufacturer: DDS; Product Number: LI-20130102-010; Ins thickness: ins= 0.000000 mm; Length: 200.0 m; Model Number: Dra.no: 4; Layer number: 21; Main string number: 00; Project name: OpenBIM; Height: 0; Insulation k-value: 0; Pressure drop: 0; Insulation WSVO: 0; Flow (m\X\B3/h): 0.0 m\X\B3/h; Floor number: Storey: 5; Flow (l/h): 0.000000 l/h; Pipe thickness:: x0.0; Part number: .000; Mtg. above Finished Floor ref Center: CC= -0.15m FFB; Sub string number: .0000; Mtg. Below Ceiling ref Center: CC= 3.52m FCL; Outside dimension: 0.000000; Rotation: 0.000000; Product: PE end fitting DN 110; Building Part: Building: 0; Mtg. Below Ceiling ref Top: Top= 0.00m FCL; Flow (l/s): 0.00 l/s; Abs. pressure: 0.0 Pa; Velocity: 0.00 m/s
AC_Pset_RenovationAndPhasing - Renovation Status: Existing
Name | Y | Above Sea Level ref. Bottom | Medium | X | Width | Mtg. Above Slab ref Bottom | Dimension DN
PipLid | Y=11.21 | NNUK=10.03 m | Sewer | X=29.65 | 125 | Edge= -0.21m SSL | 125 mm
PipLid | Y=14.12 | NNUK=10.05 m | Smoke Exhaust | X=8.06 | 100 | Edge= -0.20m SSL | 100 mm

# IfcFlowFitting: LIFr250 (2)
In: 00 Ground floor
Type - Description: End cap circular DN 250; ApplicableOccurrence: Circ; PredefinedType: OBSTRUCTION
Type - Pset_ManufacturerTypeInformation - ArticleNumber: LIFr250; ModelReference: End cap circular DN 250; Manufacturer: DDS
Type - Pset_DuctFittingTypeCommon - NominalDiameterOrWidth: 250
Material: IFC Building Material; Group: Supply air
Pset_DDS - Mounting Height: 3.00 m; Above Sea Level ref. Center: NN=2.80 m; Main string number: 01; Manufacturer: DDS; Ins thickness: ins= 0.000000 mm; Length: 1.0 m; System Name: Supply Air; Medium: Supply Air; Room tekst: Office; Model Number: Dra.no: 1; Layer number: 10; Product: End cap circular DN 250; Product Number: LIFr250; Project name: OpenBIM; Height: 0; Insulation k-value: 0; Pressure drop: 0; Insulation WSVO: 0; Flow (m\X\B3/h): 0.0 m\X\B3/h; Dimension DN: 250 mm; Floor number: Storey: 2; Width: 250; Flow (l/h): 0.000000 l/h; Pipe thickness:: x0.0; Above Sea Level ref. Bottom: NNUK=2.55 m; Sub string number: .0000; Outside dimension: 0.000000; Rotation: 0.000000; Building Part: Building: 0; Flow (l/s): 0.00 l/s; Abs. pressure: 0.0 Pa; Velocity: 0.00 m/s
AC_Pset_RenovationAndPhasing - Renovation Status: Existing
Name | Mtg. Above Slab ref Center | Y | Mtg. Below Ceiling ref Center | Part number | Room number | X | Mtg. Above Slab ref Bottom | Mtg. above Finished Floor ref Center | Mtg. Below Ceiling ref Top
1.0.12 | CC= 3.12m SSL | Y=18.27 | CC= 0.18m FCL | .012 | 00.23 | X=38.36 | Edge= 3.00m SSL | CC= 3.12m FFB | Top= 0.05m FCL
1.0.19 | CC= 3.00m SSL | Y=13.72 | CC= 0.30m FCL | .019 | 00.19 | X=6.55 | Edge= 2.88m SSL | CC= 3.00m FFB | Top= 0.17m FCL

# IfcFlowFitting: QA-030916-003 (7)
Type - Description: Bend for cable tray 300 mm; ApplicableOccurrence: Bends; PredefinedType: BEND
Type - Pset_ManufacturerTypeInformation - ArticleNumber: QA-030916-003; ModelReference: Bend for cable tray 300 mm; Manufacturer: DDS
Material: IFC Building Material
Pset_DDS - Radius: 50 mm; Product Number: QA-030916-003; Angle: 90 Degrees; Product: Bend for cable tray 300 mm; Dimension: 300 x 55 mm; Manufacturer: DDS; Layer number: 42; Project name: OpenBIM; Mounting Height: 3 m; Building Part: Building: 0
Pset_ElectricalCostData - SystemCodeValue: 42; ProductCodeValue: WP2.2; Location: NOR; ProductCodeName: NS3420; CostCodeName: Eldata Kode; SystemCodeName: NS3451; CostCodeValue: A-030916-003
AC_Pset_RenovationAndPhasing - Renovation Status: Existing
Name | In | Mtg. Below Ceiling ref Top | Above Sea Level ref. Center | Mtg. Above Slab ref Bottom | Y | Model Number | Floor number | Mtg. above Finished Floor ref Center | Room tekst | Mtg. Below Ceiling ref Center | Above Sea Level ref. Bottom | Room number | X | Mtg. Above Slab ref Center
Bend | 00 Ground floor | Top= 0.52m FCL | NN=2.55 m | Edge= 2.72m SSL | Y=17.65 | Dra.no: 1 | Storey: 2 | CC= 2.75m FFB | Hallway | CC= 0.55m FCL | NNUK=2.52 m | 00.03 | X=24.23 | CC= 2.75m SSL
Bend | 00 Ground floor | Top= 0.52m FCL | NN=2.55 m | Edge= 2.72m SSL | Y=17.65 | Dra.no: 1 | Storey: 2 | CC= 2.75m FFB | Hallway | CC= 0.55m FCL | NNUK=2.52 m | 00.03 | X=32.94 | CC= 2.75m SSL
Bend | 00 Ground floor | Top= 0.65m FCL | NN=2.55 m | Edge= 2.59m SSL | Y=10.15 | Dra.no: 1 | Storey: 2 | CC= 2.62m FFB | Director office | CC= 0.68m FCL | NNUK=2.52 m | 00.25 | X=32.94 | CC= 2.62m SSL
Bend | 00 Ground floor | Top= 0.52m FCL | NN=2.55 m | Edge= 2.72m SSL | Y=16.66 | Dra.no: 1 | Storey: 2 | CC= 2.75m FFB | Hallway | CC= 0.55m FCL | NNUK=2.52 m | 00.03 | X=24.23 | CC= 2.75m SSL
Bend | 01 First floor | Top= 0.60m FCL | NN=6.10 m | Edge= 2.64m SSL | Y=16.90 | Dra.no: 2 | Storey: 3 | CC= 2.67m FFB | Hallway | CC= 0.63m FCL | NNUK=6.07 m | 01.02 | X=32.35 | CC= 2.67m SSL
Bend | 01 First floor | Top= 0.60m FCL | NN=6.10 m | Edge= 2.64m SSL | Y=11.31 | Dra.no: 2 | Storey: 3 | CC= 2.67m FFB | Restaurant | CC= 0.63m FCL | NNUK=6.07 m | 01.03 | X=32.35 | CC= 2.67m SSL
Bend | 01 First floor | Top= 0.00m FCL | NN=6.10 m | Edge= 2.77m SSL | Y=11.31 | Dra.no: 2 | Storey: 3 | CC= 2.80m FFB |  | CC= 0.50m FCL | NNUK=6.07 m |  | X=30.65 | CC= 2.80m SSL

# IfcFlowFitting: QA-070122-004 (2)
In: 01 First floor
Type - Description: Plate for cable tray 300 mm; ApplicableOccurrence: Bends; PredefinedType: BEND
Type - Pset_ManufacturerTypeInformation - ArticleNumber: QA-070122-004; ModelReference: Plate for cable tray 300 mm; Manufacturer: DDS
Material: IFC Building Material
Pset_DDS - Radius: 50 mm; Mtg. Below Ceiling ref Center: CC= 0.63m FCL; Room number: 01.02; Product: Plate for cable tray 300 mm; Mtg. Above Slab ref Bottom: Edge= 2.64m SSL; Dimension: 300 x 55 mm; Manufacturer: DDS; Above Sea Level ref. Bottom: NNUK=6.07 m; Above Sea Level ref. Center: NN=6.10 m; Mtg. above Finished Floor ref Center: CC= 2.67m FFB; Product Number: QA-070122-004; Model Number: Dra.no: 2; Angle: 45 Degrees; Mtg. Below Ceiling ref Top: Top= 0.60m FCL; Layer number: 42; Project name: OpenBIM; Mtg. Above Slab ref Center: CC= 2.67m SSL; Floor number: Storey: 3; Mounting Height: 3 m; Room tekst: Hallway; Building Part: Building: 0
Pset_ElectricalCostData - SystemCodeValue: 42; ProductCodeValue: WP2.2; Location: NOR; ProductCodeName: NS3420; CostCodeName: Eldata Kode; SystemCodeName: NS3451; CostCodeValue: A-070122-004
AC_Pset_RenovationAndPhasing - Renovation Status: Existing
Name | Y | X
Bend | Y=16.71 | X=24.19
Bend | Y=16.90 | X=24.37

# IfcFlowFitting: QT-061124-019, Tee
In: 00 Ground floor
Type - Description: Tee for cable tray 300 mm exit 300 mm; ApplicableOccurrence: Tees; PredefinedType: TEE
Type - Pset_ManufacturerTypeInformation - ArticleNumber: QT-061124-019; ModelReference: Tee for cable tray 300 mm exit 300 mm; Manufacturer: DDS
Material: IFC Building Material
Pset_ElectricalCostData - SystemCodeValue: 42; ProductCodeValue: WP2.2; Location: NOR; ProductCodeName: NS3420; CostCodeValue: T-061124-019; CostCodeName: Eldata Kode; SystemCodeName: NS3451
Pset_DDS - Mtg. Above Slab ref Center: CC= 2.62m SSL; Radius: 50 mm; Above Sea Level ref. Center: NN=2.55 m; X: X=30.65; Dimension: 300 x 55 mm; Product Number: QT-061124-019; Manufacturer: DDS; Dimension F: 100 mm; Dimension E: 100 mm; Tee Length: 500 mm; Dimension in/ Dimension B: 300 mm; Dimension out / Dimension D: 300 mm; Dimension out of Tee / Dimension H: 300 mm; Room tekst: FB; Y: Y=10.15; Room number: 00.15; Mtg. Below Ceiling ref Center: CC= 0.68m FCL; Model Number: Dra.no: 1; Mtg. Below Ceiling ref Top: Top= 0.65m FCL; Layer number: 42; Project name: OpenBIM; Floor number: Storey: 2; Mtg. Above Slab ref Bottom: Edge= 2.59m SSL; Above Sea Level ref. Bottom: NNUK=2.52 m; Product: Tee for cable tray 300 mm exit 300 mm; Mounting Height: 55 mm; Building Part: Building: 0; Mtg. above Finished Floor ref Center: CC= 2.62m FFB
AC_Pset_RenovationAndPhasing - Renovation Status: Existing

# IfcFlowFitting: QZ-070201-004, Bend
In: 00 Ground floor
Type - Description: Plate up down cable tray 300 mm normal; ApplicableOccurrence: Plates up down; PredefinedType: BEND
Type - Pset_ManufacturerTypeInformation - ArticleNumber: QZ-070201-004; ModelReference: Plate up down cable tray 300 mm normal; Manufacturer: DDS
Material: IFC Building Material
Pset_DDS - Mtg. Above Slab ref Center: CC= 2.62m SSL; Product Number: QZ-070201-004; Radius: 50 mm; Product: Plate up down cable tray 300 mm normal; Above Sea Level ref. Center: NN=2.55 m; X: X=30.65; Angle: 90 Degrees; Dimension: 300 x 55 mm; Manufacturer: DDS; Y: Y=10.91; Mtg. Below Ceiling ref Center: CC= 0.68m FCL; Model Number: Dra.no: 1; Mtg. Below Ceiling ref Top: Top= 0.65m FCL; Layer number: 42; Room number: 00.27; Project name: OpenBIM; Room tekst: Shaft; Floor number: Storey: 2; Mtg. Above Slab ref Bottom: Edge= 2.59m SSL; Mounting Height: 3 m; Above Sea Level ref. Bottom: NNUK=2.52 m; Building Part: Building: 0; Mtg. above Finished Floor ref Center: CC= 2.62m FFB
Pset_ElectricalCostData - CostCodeValue: Z-070201-004; SystemCodeValue: 42; ProductCodeValue: WP2.2; Location: NOR; ProductCodeName: NS3420; CostCodeName: Eldata Kode; SystemCodeName: NS3451
AC_Pset_RenovationAndPhasing - Renovation Status: Existing

# IfcFlowFitting: T83014001250140 (2)
In: 00 Ground floor
Type - Description: Tee Folded Spiral-seam Circ 90\X\B0 140/125/140; ApplicableOccurrence: Circ; PredefinedType: JUNCTION
Type - Pset_ManufacturerTypeInformation - ArticleNumber: T83014001250140; ModelReference: Tee Folded Spiral-seam Circ 90\X\B0 140/125/140; Manufacturer: DDS
Type - Pset_DuctFittingTypeCommon - NominalDiameterOrWidth: 140, 125, 140; NominalHeight: 200, 125, 140
Material: IFC Building Material
Pset_DDS - Above Sea Level ref. Bottom: NNUK=2.66 m; Mounting Height: 3.00 m; Width: 140; Dimension B: 140; Above Sea Level ref. Center: NN=2.80 m; Product Number: T83014001250140; Dimension I: 0mm; Dimension E: 115; Sub string number: .0030; Manufacturer: DDS; Tee dimension: 125; Ins thickness: ins= 0.000000 mm; Product: Tee Folded Spiral-seam Circ 90\X\B0 140/125/140; Length: 205.0 m; Model Number: Dra.no: 1; Outside dimension: 140.000000; Dimension L: 205; Dimension F: 103; Project name: OpenBIM; Dimension R: 0; Dimension M: 0; Dimension A: 0; Tee dimension height: 0; Height: 0; Insulation k-value: 0; Pressure drop: 0; Insulation WSVO: 0; Floor number: Storey: 2; Pipe thickness:: x0.0; Dimension DN: 140 mm; Rotation: 0.000000; Building Part: Building: 0
AC_Pset_RenovationAndPhasing - Renovation Status: Existing
Name | Mtg. Below Ceiling ref Center | Abs. pressure | Main string number | Y | Flow (m\X\B3/h) | Part number | Mtg. above Finished Floor ref Center | Medium | X | Flow (l/s) | Layer number | Room number | Flow (l/h) | Mtg. Above Slab ref Center | Room tekst | Mtg. Above Slab ref Bottom | Mtg. Below Ceiling ref Top | Velocity
1.30.4 | CC= 0.43m FCL | 248.9 Pa | 01 | Y=9.28 | 200.0 m\X\B3/h | .004 | CC= 2.87m FFB | Supply Air | X=35.00 | 55.56 l/s | 10 | 00.25 | 200000.000000 l/h | CC= 2.87m SSL | Director office | Edge= 2.80m SSL | Top= 0.36m FCL | 1.80 m/s | Pset_DDS - System Name: Supply Air; Group: Supply air
Tee | CC= 0.30m FCL | 0.0 Pa | 00 | Y=13.91 | 0.0 m\X\B3/h | .000 | CC= 3.00m FFB | Extract Air | X=23.79 | 0.00 l/s | 11 | 00.03 | 0.000000 l/h | CC= 3.00m SSL | Hallway | Edge= 2.93m SSL | Top= 0.23m FCL | 0.00 m/s

# IfcFlowFitting: T83016001250160, 1.29.6
In: 00 Ground floor
Type - Description: Tee Folded Spiral-seam Circ 90\X\B0 160/125/160; ApplicableOccurrence: Circ; PredefinedType: JUNCTION
Type - Pset_ManufacturerTypeInformation - ArticleNumber: T83016001250160; ModelReference: Tee Folded Spiral-seam Circ 90\X\B0 160/125/160; Manufacturer: DDS
Type - Pset_DuctFittingTypeCommon - NominalDiameterOrWidth: 160, 125, 160; NominalHeight: 200, 125, 160
Material: IFC Building Material; Group: Supply air
Pset_DDS - X: X=33.12; Dimension DN: 160 mm; Above Sea Level ref. Bottom: NNUK=2.64 m; Part number: .006; Mounting Height: 3.00 m; Above Sea Level ref. Center: NN=2.80 m; Mtg. Below Ceiling ref Center: CC= 0.43m FCL; Dimension I: 0mm; Velocity: 2.76 m/s; Main string number: 01; Y: Y=9.28; Manufacturer: DDS; Dimension E: 125; Tee dimension: 125; Ins thickness: ins= 0.000000 mm; Mtg. above Finished Floor ref Center: CC= 2.87m FFB; System Name: Supply Air; Medium: Supply Air; Product: Tee Folded Spiral-seam Circ 90\X\B0 160/125/160; Length: 205.0 m; Model Number: Dra.no: 1; Layer number: 10; Dimension L: 205; Dimension F: 103; Sub string number: .0029; Room number: 00.25; Project name: OpenBIM; Dimension R: 0; Dimension M: 0; Dimension A: 0; Tee dimension height: 0; Height: 0; Insulation k-value: 0; Pressure drop: 0; Insulation WSVO: 0; Mtg. Above Slab ref Center: CC= 2.87m SSL; Outside dimension: 160.000000; Flow (m\X\B3/h): 0.0 m\X\B3/h; Floor number: Storey: 2; Mtg. Above Slab ref Bottom: Edge= 2.79m SSL; Flow (l/h): 0.000000 l/h; Pipe thickness:: x0.0; Product Number: T83016001250160; Width: 160; Dimension B: 160; Abs. pressure: 252.4 Pa; Room tekst: Director office; Rotation: 0.000000; Mtg. Below Ceiling ref Top: Top= 0.35m FCL; Building Part: Building: 0; Flow (l/s): 0.00 l/s
AC_Pset_RenovationAndPhasing - Renovation Status: Existing

# IfcFlowFitting: T83031502500315, 1.4.14
In: 00 Ground floor
Type - Description: Tee Folded Spiral-seam Circ 90\X\B0 315/250/315; ApplicableOccurrence: Circ; PredefinedType: JUNCTION
Type - Pset_ManufacturerTypeInformation - ArticleNumber: T83031502500315; ModelReference: Tee Folded Spiral-seam Circ 90\X\B0 315/250/315; Manufacturer: DDS
Type - Pset_DuctFittingTypeCommon - NominalDiameterOrWidth: 315, 250, 315; NominalHeight: 300, 250, 315
Material: IFC Building Material; Group: Supply air
Pset_DDS - Dimension DN: 315 mm; Mounting Height: 3.00 m; Above Sea Level ref. Center: NN=2.80 m; Above Sea Level ref. Bottom: NNUK=2.49 m; Dimension I: 0mm; Mtg. Below Ceiling ref Center: CC= 0.30m FCL; Velocity: 3.56 m/s; X: X=18.47; Rotation: 180.000000; Main string number: 01; Dimension B: 315; Width: 315; Mtg. Above Slab ref Bottom: Edge= 2.84m SSL; Mtg. above Finished Floor ref Center: CC= 3.00m FFB; Manufacturer: DDS; Dimension E: 223; Mtg. Above Slab ref Center: CC= 3.00m SSL; Ins thickness: ins= 0.000000 mm; Abs. pressure: 110.1 Pa; Part number: .014; Flow (m\X\B3/h): 2000.0 m\X\B3/h; System Name: Supply Air; Outside dimension: 315.000000; Medium: Supply Air; Y: Y=18.25; Dimension L: 370; Dimension F: 185; Room tekst: Office; Length: 370.0 m; Model Number: Dra.no: 1; Layer number: 10; Room number: 001; Project name: OpenBIM; Dimension R: 0; Dimension M: 0; Dimension A: 0; Tee dimension height: 0; Height: 0; Insulation k-value: 0; Pressure drop: 0; Insulation WSVO: 0; Floor number: Storey: 2; Product: Tee Folded Spiral-seam Circ 90\X\B0 315/250/315; Tee dimension: 250; Pipe thickness:: x0.0; Sub string number: .0004; Mtg. Below Ceiling ref Top: Top= 0.14m FCL; Flow (l/h): 2000000.000000 l/h; Building Part: Building: 0; Product Number: T83031502500315; Flow (l/s): 555.56 l/s
AC_Pset_RenovationAndPhasing - Renovation Status: Existing

# IfcFlowFitting: TA-20110701-001, 1.23.6
In: 00 Ground floor
Type - Description: Transit free; PredefinedType: TRANSITION
Type - Pset_ManufacturerTypeInformation - ArticleNumber: TA-20110701-001; ModelReference: Transit free; Manufacturer: DDS
Type - Pset_DuctFittingTypeCommon - NominalDiameterOrWidth: 400, 400; NominalHeight: 300, 200
Material: IFC Building Material; Group: Supply air
Pset_DDS - Product: Transit free; Part number: .006; Mounting Height: 3.00 m; Above Sea Level ref. Center: NN=2.80 m; Flow (l/s): 236.11 l/s; Mtg. Below Ceiling ref Center: CC= 0.43m FCL; Mtg. Above Slab ref Bottom: Edge= 2.72m SSL; Main string number: 01; Manufacturer: DDS; Ins thickness: ins= 0.000000 mm; Mtg. Below Ceiling ref Top: Top= 0.28m FCL; Mtg. above Finished Floor ref Center: CC= 2.87m FFB; System Name: Supply Air; Medium: Supply Air; Pipe thickness:: x1.1; Flow (l/h): 850000.000000 l/h; Product Number: TA-20110701-001; Length: 170.0 m; Model Number: Dra.no: 1; Layer number: 10; Height: 300; Width: 400; Sub string number: .0023; Room number: 00.25; Flow (m\X\B3/h): 850.0 m\X\B3/h; Project name: OpenBIM; Insulation k-value: 0; Pressure drop: 0; Insulation WSVO: 0; Mtg. Above Slab ref Center: CC= 2.87m SSL; Floor number: Storey: 2; Velocity: 1.91 m/s; Abs. pressure: 267.2 Pa; Outside dimension: 400.000000; Dimension DN: 400 x 300 mm; X: X=31.41; Above Sea Level ref. Bottom: NNUK=2.50 m; Room tekst: Director office; Y: Y=8.14; Rotation: 0.000000; Building Part: Building: 0
AC_Pset_RenovationAndPhasing - Renovation Status: Existing

# IfcFlowFitting: TA-20120326-013, 1.4.5
In: 00 Ground floor
Type - Description: Transit \X\D8 200 to Duct; PredefinedType: TRANSITION
Type - Pset_ManufacturerTypeInformation - ArticleNumber: TA-20120326-013; ModelReference: Transit \X\D8 200 to Duct; Manufacturer: DDS
Type - Pset_DuctFittingTypeCommon - NominalDiameterOrWidth: 200, 315; NominalHeight: 300, 315
Material: IFC Building Material; Group: Supply air
Pset_DDS - Mounting Height: 3.00 m; Velocity: 7.84 m/s; Above Sea Level ref. Center: NN=2.80 m; Length: 75.0 m; Mtg. Below Ceiling ref Center: CC= 0.30m FCL; Main string number: 01; X: X=25.21; Mtg. above Finished Floor ref Center: CC= 3.00m FFB; Manufacturer: DDS; Mtg. Above Slab ref Center: CC= 3.00m SSL; Ins thickness: ins= 0.000000 mm; Product: Transit \X\D8 200 to Duct; System Name: Supply Air; Medium: Supply Air; Pipe thickness:: x1.1; Model Number: Dra.no: 1; Layer number: 10; Width: 200; Height: 300; Project name: OpenBIM; Insulation k-value: 0; Pressure drop: 0; Insulation WSVO: 0; Floor number: Storey: 2; Product Number: TA-20120326-013; Room tekst: Hallway; Mtg. Above Slab ref Bottom: Edge= 2.85m SSL; Abs. pressure: 165.1 Pa; Flow (l/s): 611.11 l/s; Outside dimension: 200.000000; Flow (l/h): 2200000.000000 l/h; Y: Y=18.32; Above Sea Level ref. Bottom: NNUK=2.50 m; Sub string number: .0004; Room number: 00.03; Dimension DN: 200 x 300 mm; Mtg. Below Ceiling ref Top: Top= 0.15m FCL; Rotation: 0.000000; Building Part: Building: 0; Part number: .005; Flow (m\X\B3/h): 2200.0 m\X\B3/h
AC_Pset_RenovationAndPhasing - Renovation Status: Existing

# IfcFlowFitting: TA-20120326-017, 1.18.6
In: 00 Ground floor
Type - Description: Transit \X\D8 300 to Duct; PredefinedType: TRANSITION
Type - Pset_ManufacturerTypeInformation - ArticleNumber: TA-20120326-017; ModelReference: Transit \X\D8 300 to Duct; Manufacturer: DDS
Type - Pset_DuctFittingTypeCommon - NominalDiameterOrWidth: 300, 250; NominalHeight: 300, 250
Material: IFC Building Material; Group: Supply air
Pset_DDS - Mtg. Above Slab ref Center: CC= 3.12m SSL; Part number: .006; Mounting Height: 3.00 m; Velocity: 1.22 m/s; Above Sea Level ref. Center: NN=2.80 m; Length: 75.0 m; Flow (l/s): 60.00 l/s; Main string number: 01; X: X=35.23; Abs. pressure: 225.1 Pa; Manufacturer: DDS; Ins thickness: ins= 0.000000 mm; Product: Transit \X\D8 300 to Duct; Flow (m\X\B3/h): 216.0 m\X\B3/h; System Name: Supply Air; Medium: Supply Air; Y: Y=18.27; Pipe thickness:: x1.1; Sub string number: .0018; Mtg. Below Ceiling ref Center: CC= 0.18m FCL; Room tekst: Office; Model Number: Dra.no: 1; Layer number: 10; Height: 300; Width: 300; Room number: 00.23; Project name: OpenBIM; Insulation k-value: 0; Pressure drop: 0; Insulation WSVO: 0; Floor number: Storey: 2; Product Number: TA-20120326-017; Outside dimension: 300.000000; Above Sea Level ref. Bottom: NNUK=2.50 m; Dimension DN: 300 x 300 mm; Rotation: 0.000000; Building Part: Building: 0; Mtg. above Finished Floor ref Center: CC= 3.12m FFB; Mtg. Below Ceiling ref Top: Top= 0.03m FCL; Flow (l/h): 216000.000000 l/h; Mtg. Above Slab ref Bottom: Edge= 2.97m SSL
AC_Pset_RenovationAndPhasing - Renovation Status: Existing

# IfcFlowFitting: TP-121203-034 (8)
Type - Description: HT tee 45\X\B0 100x50; ApplicableOccurrence: Generic; PredefinedType: JUNCTION
