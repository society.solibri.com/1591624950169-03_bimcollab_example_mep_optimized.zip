Properties of the parts of a building model (IFC2X3), part 7 of 14

# IfcFlowFitting: TP2000.BIM (22)
Name | Mtg. Above Slab ref Center | Y | Mounting Height | X | Mtg. Below Ceiling ref Center | Mtg. Below Ceiling ref Top | Above Sea Level ref. Center | Room tekst | Layer number | Mtg. Above Slab ref Bottom | Room number | Above Sea Level ref. Bottom | Mtg. above Finished Floor ref Center | Medium
Tee | CC= -0.20m SSL | Y=22.09 | -0.20 m | X=9.52 | CC= 3.50m FCL | Top= 3.48m FCL | NN=-0.40 m | Office | 5 | Edge= -0.22m SSL | 00.20 | NNUK=-0.43 m | CC= -0.20m FFB | Heat flow
Tee | CC= -0.20m SSL | Y=22.09 | -0.20 m | X=7.27 | CC= 3.50m FCL | Top= 3.48m FCL | NN=-0.40 m | Staircase | 5 | Edge= -0.22m SSL | 00.05 | NNUK=-0.43 m | CC= -0.20m FFB | Heat flow
Tee | CC= -0.20m SSL | Y=21.42 | -0.20 m | X=5.47 | CC= 3.50m FCL | Top= 3.48m FCL | NN=-0.40 m | Staircase | 5 | Edge= -0.22m SSL | 00.05 | NNUK=-0.43 m | CC= -0.20m FFB | Heat flow

# IfcFlowFitting: TPR0125, Tee
In: 00 Ground floor
Type - Description: Collar Saddle in Circular Duct 90\X\B0, Circular d 125 mm; ApplicableOccurrence: Circ; PredefinedType: JUNCTION
Type - Pset_ManufacturerTypeInformation - ArticleNumber: TPR0125; ModelReference: Collar Saddle in Circular Duct 90\X\B0, Circular d 125 mm; Manufacturer: DDS; ModelLabel: GT
Type - Pset_DuctFittingTypeCommon - NominalDiameterOrWidth: 160, 125, 160; NominalHeight: 300, 125, 160
Material: IFC Building Material
Pset_DDS - Dimension DN: 160 mm; Above Sea Level ref. Bottom: NNUK=2.64 m; Mounting Height: 3.00 m; Above Sea Level ref. Center: NN=2.80 m; Dimension I: 0mm; Mtg. Below Ceiling ref Center: CC= 0.30m FCL; Mtg. Above Slab ref Bottom: Edge= 2.92m SSL; Sub string number: .0030; Mtg. above Finished Floor ref Center: CC= 3.00m FFB; Manufacturer: DDS; Tee dimension: 125; Dimension L: 125; Mtg. Above Slab ref Center: CC= 3.00m SSL; Ins thickness: ins= 0.000000 mm; Mtg. Below Ceiling ref Top: Top= 0.22m FCL; Y: Y=13.02; Model Number: Dra.no: 1; Layer number: 11; Length: 125.0 m; Main string number: 00; Project name: OpenBIM; Dimension R: 0; Dimension M: 0; Dimension F: 0; Dimension A: 0; Tee dimension height: 0; Height: 0; Insulation k-value: 0; Pressure drop: 0; Insulation WSVO: 0; Outside dimension: 160.000000; Flow (m\X\B3/h): 0.0 m\X\B3/h; Floor number: Storey: 2; Room tekst: corridor; X: X=20.21; Dimension E: 15; Flow (l/h): 0.000000 l/h; Pipe thickness:: x0.0; Part number: .000; Width: 160; Dimension B: 160; Room number: 00.04; Rotation: 0.000000; Product Number: TPR0125; Product: Collar Saddle in Circular Duct 90\X\B0, Circular d 125 mm; Building Part: Building: 0; Flow (l/s): 0.00 l/s; Medium: Extract Air; Abs. pressure: 0.0 Pa; Velocity: 0.00 m/s
AC_Pset_RenovationAndPhasing - Renovation Status: Existing

# IfcFlowFitting: TPR0125, Tee
In: 00 Ground floor
Type - Description: Collar Saddle in Circular Duct 90\X\B0, Circular d 125 mm; ApplicableOccurrence: Circ; PredefinedType: JUNCTION
Type - Pset_ManufacturerTypeInformation - ArticleNumber: TPR0125; ModelReference: Collar Saddle in Circular Duct 90\X\B0, Circular d 125 mm; Manufacturer: DDS; ModelLabel: GT
Type - Pset_DuctFittingTypeCommon - NominalDiameterOrWidth: 200, 125, 200; NominalHeight: 300, 125, 200
Material: IFC Building Material
Pset_DDS - Above Sea Level ref. Bottom: NNUK=2.60 m; Mounting Height: 3.00 m; Above Sea Level ref. Center: NN=2.80 m; Dimension I: 0mm; Mtg. Below Ceiling ref Center: CC= 0.30m FCL; Sub string number: .0030; Rotation: 179.999998; Mtg. above Finished Floor ref Center: CC= 3.00m FFB; Manufacturer: DDS; Tee dimension: 125; Dimension L: 125; Dimension DN: 200 mm; Y: Y=13.30; Mtg. Above Slab ref Center: CC= 3.00m SSL; Ins thickness: ins= 0.000000 mm; Mtg. Below Ceiling ref Top: Top= 0.20m FCL; Model Number: Dra.no: 1; Layer number: 11; Length: 125.0 m; Main string number: 00; Dimension B: 200; Width: 200; Project name: OpenBIM; Dimension R: 0; Dimension M: 0; Dimension F: 0; Dimension A: 0; Tee dimension height: 0; Height: 0; Insulation k-value: 0; Pressure drop: 0; Insulation WSVO: 0; Flow (m\X\B3/h): 0.0 m\X\B3/h; Floor number: Storey: 2; Room tekst: corridor; X: X=20.21; Dimension E: 15; Outside dimension: 200.000000; Flow (l/h): 0.000000 l/h; Pipe thickness:: x0.0; Part number: .000; Room number: 00.04; Mtg. Above Slab ref Bottom: Edge= 2.90m SSL; Product Number: TPR0125; Product: Collar Saddle in Circular Duct 90\X\B0, Circular d 125 mm; Building Part: Building: 0; Flow (l/s): 0.00 l/s; Medium: Extract Air; Abs. pressure: 0.0 Pa; Velocity: 0.00 m/s
AC_Pset_RenovationAndPhasing - Renovation Status: Existing

# IfcFlowFitting: TPR0125 (4)
In: 00 Ground floor
Type - Description: Collar Saddle in Circular Duct 90\X\B0, Circular d 125 mm; ApplicableOccurrence: Circ; PredefinedType: JUNCTION
Type - Pset_ManufacturerTypeInformation - ArticleNumber: TPR0125; ModelReference: Collar Saddle in Circular Duct 90\X\B0, Circular d 125 mm; Manufacturer: DDS; ModelLabel: GT
Type - Pset_DuctFittingTypeCommon - NominalDiameterOrWidth: 250, 125, 250; NominalHeight: 300, 125, 250
Material: IFC Building Material
Pset_DDS - Mounting Height: 3.00 m; Above Sea Level ref. Center: NN=2.80 m; Dimension I: 0mm; Outside dimension: 250.000000; Manufacturer: DDS; Tee dimension: 125; Dimension L: 125; Ins thickness: ins= 0.000000 mm; Model Number: Dra.no: 1; Length: 125.0 m; Project name: OpenBIM; Dimension R: 0; Dimension M: 0; Dimension A: 0; Tee dimension height: 0; Height: 0; Insulation k-value: 0; Pressure drop: 0; Insulation WSVO: 0; Dimension DN: 250 mm; Floor number: Storey: 2; Dimension E: 15; Dimension B: 250; Width: 250; Pipe thickness:: x0.0; Above Sea Level ref. Bottom: NNUK=2.55 m; Product Number: TPR0125; Product: Collar Saddle in Circular Duct 90\X\B0, Circular d 125 mm; Building Part: Building: 0
AC_Pset_RenovationAndPhasing - Renovation Status: Existing
Name | Mtg. Above Slab ref Center | X | Flow (l/h) | Flow (l/s) | Main string number | Abs. pressure | Flow (m\X\B3/h) | Medium | Y | Sub string number | Mtg. Below Ceiling ref Center | Room tekst | Layer number | Room number | Velocity | Part number | Dimension F | Mtg. Above Slab ref Bottom | Rotation | Mtg. above Finished Floor ref Center | Mtg. Below Ceiling ref Top
1.18.10 | CC= 3.12m SSL | X=38.19 | 108000.000000 l/h | 30.00 l/s | 01 | 224.9 Pa | 108.0 m\X\B3/h | Supply Air | Y=18.27 | .0018 | CC= 0.18m FCL | Office | 10 | 00.23 | 0.61 m/s | .010 | 165 | Edge= 3.00m SSL | 0.000000 | CC= 3.12m FFB | Top= 0.05m FCL | Pset_DDS - System Name: Supply Air; Group: Supply air
1.18.9 | CC= 3.12m SSL | X=38.19 | 216000.000000 l/h | 60.00 l/s | 01 | 224.9 Pa | 216.0 m\X\B3/h | Supply Air | Y=18.27 | .0018 | CC= 0.18m FCL | Office | 10 | 00.23 | 0.61 m/s | .009 | 165 | Edge= 3.00m SSL | 180.000000 | CC= 3.12m FFB | Top= 0.05m FCL | Pset_DDS - System Name: Supply Air; Group: Supply air
Tee | CC= 3.00m SSL | X=20.21 | 0.000000 l/h | 0.00 l/s | 00 | 0.0 Pa | 0.0 m\X\B3/h | Extract Air | Y=14.54 | .0030 | CC= 0.30m FCL | corridor | 11 | 00.04 | 0.00 m/s | .000 | 0 | Edge= 2.88m SSL | 0.000000 | CC= 3.00m FFB | Top= 0.17m FCL
Tee | CC= 3.00m SSL | X=20.21 | 0.000000 l/h | 0.00 l/s | 00 | 0.0 Pa | 0.0 m\X\B3/h | Extract Air | Y=13.85 | .0030 | CC= 0.30m FCL | corridor | 11 | 00.04 | 0.00 m/s | .000 | 0 | Edge= 2.88m SSL | 0.000000 | CC= 3.00m FFB | Top= 0.17m FCL

# IfcFlowFitting: TPR0160 (5)
In: 00 Ground floor
Type - Description: Collar Saddle in Circular Duct 90\X\B0, Circular d 125 mm; ApplicableOccurrence: Circ; PredefinedType: JUNCTION
Type - Pset_ManufacturerTypeInformation - ArticleNumber: TPR0160; ModelReference: Collar Saddle in Circular Duct 90\X\B0, Circular d 125 mm; Manufacturer: DDS; ModelLabel: GT
Type - Pset_DuctFittingTypeCommon - NominalDiameterOrWidth: 250, 160, 250; NominalHeight: 300, 160, 250
Material: IFC Building Material; Group: Supply air
Pset_DDS - Mounting Height: 3.00 m; Above Sea Level ref. Center: NN=2.80 m; Product: Collar Saddle in Circular Duct 90\X\B0, Circular d 125 mm; Dimension I: 0mm; Mtg. Below Ceiling ref Center: CC= 0.30m FCL; Outside dimension: 250.000000; Main string number: 01; Mtg. Above Slab ref Bottom: Edge= 2.88m SSL; Rotation: 179.999998; Mtg. above Finished Floor ref Center: CC= 3.00m FFB; Manufacturer: DDS; Mtg. Above Slab ref Center: CC= 3.00m SSL; Ins thickness: ins= 0.000000 mm; System Name: Supply Air; Medium: Supply Air; Product Number: TPR0160; Sub string number: .0011; Length: 160.0 m; Room tekst: Office; Model Number: Dra.no: 1; Layer number: 10; Project name: OpenBIM; Dimension R: 0; Dimension M: 0; Dimension F: 0; Dimension A: 0; Tee dimension height: 0; Height: 0; Insulation k-value: 0; Pressure drop: 0; Insulation WSVO: 0; Dimension DN: 250 mm; Floor number: Storey: 2; Dimension E: 15; Dimension B: 250; Width: 250; Pipe thickness:: x0.0; Above Sea Level ref. Bottom: NNUK=2.55 m; Tee dimension: 160; Dimension L: 160; Mtg. Below Ceiling ref Top: Top= 0.17m FCL; Building Part: Building: 0
AC_Pset_RenovationAndPhasing - Renovation Status: Existing
Name | Abs. pressure | Flow (m\X\B3/h) | Room number | Flow (l/s) | Velocity | Y | Part number | X | Flow (l/h)
1.11.15 | 59.0 Pa | 400.0 m\X\B3/h | 00.19 | 111.11 l/s | 1.13 m/s | Y=13.72 | .015 | X=8.63 | 400000.000000 l/h
1.11.17 | 58.8 Pa | 200.0 m\X\B3/h | 00.19 | 55.56 l/s | 1.13 m/s | Y=13.72 | .017 | X=6.75 | 200000.000000 l/h
1.11.5 | 68.3 Pa | 1000.0 m\X\B3/h | 00.18 | 277.78 l/s | 4.53 m/s | Y=14.50 | .005 | X=17.81 | 1000000.000000 l/h
1.11.6 | 65.8 Pa | 800.0 m\X\B3/h | 00.18 | 222.22 l/s | 3.40 m/s | Y=14.50 | .006 | X=15.94 | 800000.000000 l/h
1.11.8 | 63.9 Pa | 600.0 m\X\B3/h | 00.17 | 166.67 l/s | 2.26 m/s | Y=14.50 | .008 | X=13.75 | 600000.000000 l/h

# IfcFlowFitting: TPR0160 (6)
In: 00 Ground floor
Type - Description: Collar Saddle in Circular Duct 90\X\B0, Circular d 125 mm; ApplicableOccurrence: Circ; PredefinedType: JUNCTION
Type - Pset_ManufacturerTypeInformation - ArticleNumber: TPR0160; ModelReference: Collar Saddle in Circular Duct 90\X\B0, Circular d 125 mm; Manufacturer: DDS; ModelLabel: GT
Type - Pset_DuctFittingTypeCommon - NominalDiameterOrWidth: 315, 160, 315; NominalHeight: 300, 160, 315
Material: IFC Building Material; Group: Supply air
Pset_DDS - Dimension DN: 315 mm; Mounting Height: 3.00 m; Above Sea Level ref. Center: NN=2.80 m; Above Sea Level ref. Bottom: NNUK=2.49 m; Product: Collar Saddle in Circular Duct 90\X\B0, Circular d 125 mm; Dimension I: 0mm; Mtg. Below Ceiling ref Center: CC= 0.30m FCL; Main string number: 01; Dimension B: 315; Width: 315; Mtg. Above Slab ref Bottom: Edge= 2.84m SSL; Mtg. above Finished Floor ref Center: CC= 3.00m FFB; Manufacturer: DDS; Mtg. Above Slab ref Center: CC= 3.00m SSL; Ins thickness: ins= 0.000000 mm; System Name: Supply Air; Outside dimension: 315.000000; Medium: Supply Air; Y: Y=18.25; Product Number: TPR0160; Length: 160.0 m; Room tekst: Office; Model Number: Dra.no: 1; Layer number: 10; Project name: OpenBIM; Dimension R: 0; Dimension M: 0; Dimension F: 0; Dimension A: 0; Tee dimension height: 0; Height: 0; Insulation k-value: 0; Pressure drop: 0; Insulation WSVO: 0; Floor number: Storey: 2; Dimension E: 15; Pipe thickness:: x0.0; Tee dimension: 160; Dimension L: 160; Mtg. Below Ceiling ref Top: Top= 0.14m FCL; Rotation: 0.000000; Building Part: Building: 0
AC_Pset_RenovationAndPhasing - Renovation Status: Existing
Name | Abs. pressure | Part number | Room number | Flow (l/s) | Flow (l/h) | Velocity | Sub string number | Flow (m\X\B3/h) | X
1.4.12 | 116.6 Pa | .012 | 001 | 611.11 l/s | 2200000.000000 l/h | 7.13 m/s | .0004 | 2200.0 m\X\B3/h | X=20.06
1.5.2 | 109.8 Pa | .002 | 001 | 277.78 l/s | 1000000.000000 l/h | 2.85 m/s | .0005 | 1000.0 m\X\B3/h | X=18.19
1.5.3 | 108.7 Pa | .003 | 00.21 | 222.22 l/s | 800000.000000 l/h | 2.14 m/s | .0005 | 800.0 m\X\B3/h | X=15.56
1.5.5 | 108.2 Pa | .005 | 00.21 | 166.67 l/s | 600000.000000 l/h | 1.43 m/s | .0005 | 600.0 m\X\B3/h | X=13.69
1.5.8 | 107.7 Pa | .008 | 00.20 | 111.11 l/s | 400000.000000 l/h | 0.71 m/s | .0005 | 400.0 m\X\B3/h | X=10.78
1.5.9 | 107.7 Pa | .009 | 00.20 | 55.56 l/s | 200000.000000 l/h | 0.71 m/s | .0005 | 200.0 m\X\B3/h | X=9.53

# IfcFlowFitting: TPS0125 (2)
In: 00 Ground floor
Type - Description: Collar Saddle, Circular D 125 mm; ApplicableOccurrence: Duct; PredefinedType: JUNCTION
Type - Pset_ManufacturerTypeInformation - ArticleNumber: TPS0125; ModelReference: Collar Saddle, Circular D 125 mm; Manufacturer: DDS; ModelLabel: GT
Type - Pset_DuctFittingTypeCommon - NominalDiameterOrWidth: 300, 125, 300; NominalHeight: 300, 125, 300
Material: IFC Building Material; Group: Supply air
Pset_DDS - Mtg. Above Slab ref Center: CC= 3.12m SSL; Mounting Height: 3.00 m; Above Sea Level ref. Center: NN=2.80 m; Dimension I: 0mm; Main string number: 01; Manufacturer: DDS; Product: Collar Saddle, Circular D 125 mm; Tee dimension: 125; Dimension L: 125; Ins thickness: ins= 0.000000 mm; System Name: Supply Air; Medium: Supply Air; Y: Y=18.27; Pipe thickness:: x1.1; Sub string number: .0018; Mtg. Below Ceiling ref Center: CC= 0.18m FCL; Room tekst: Office; Model Number: Dra.no: 1; Layer number: 10; Length: 125.0 m; Dimension B: 300; Dimension A: 300; Dimension F: 400; Dimension R: 100; Height: 300; Width: 300; X: X=34.97; Room number: 00.23; Project name: OpenBIM; Dimension M: 0; Tee dimension height: 0; Insulation k-value: 0; Pressure drop: 0; Insulation WSVO: 0; Floor number: Storey: 2; Dimension E: 15; Outside dimension: 300.000000; Above Sea Level ref. Bottom: NNUK=2.50 m; Dimension DN: 300 x 300 mm; Product Number: TPS0125; Building Part: Building: 0; Mtg. above Finished Floor ref Center: CC= 3.12m FFB; Mtg. Below Ceiling ref Top: Top= 0.03m FCL; Mtg. Above Slab ref Bottom: Edge= 2.97m SSL
AC_Pset_RenovationAndPhasing - Renovation Status: Existing
Name | Flow (m\X\B3/h) | Part number | Abs. pressure | Flow (l/s) | Flow (l/h) | Rotation | Velocity
1.18.3 | 432.0 m\X\B3/h | .003 | 225.5 Pa | 120.00 l/s | 432000.000000 l/h | 0.000000 | 1.00 m/s
1.18.4 | 324.0 m\X\B3/h | .004 | 225.4 Pa | 90.00 l/s | 324000.000000 l/h | 180.000000 | 0.67 m/s

# IfcFlowFitting: TPS0125, Tee
In: 00 Ground floor
Type - Description: Collar Saddle, Circular D 125 mm; ApplicableOccurrence: Duct; PredefinedType: JUNCTION
Type - Pset_ManufacturerTypeInformation - ArticleNumber: TPS0125; ModelReference: Collar Saddle, Circular D 125 mm; Manufacturer: DDS; ModelLabel: GT
Type - Pset_DuctFittingTypeCommon - NominalDiameterOrWidth: 600, 125, 600; NominalHeight: 300, 125, 300
Material: IFC Building Material
Pset_DDS - Mounting Height: 3.00 m; Above Sea Level ref. Center: NN=2.80 m; Dimension I: 0mm; Mtg. Below Ceiling ref Center: CC= 0.30m FCL; Sub string number: .0030; Mtg. above Finished Floor ref Center: CC= 3.00m FFB; Manufacturer: DDS; Product: Collar Saddle, Circular D 125 mm; Tee dimension: 125; Dimension L: 125; Mtg. Above Slab ref Center: CC= 3.00m SSL; Ins thickness: ins= 0.000000 mm; Y: Y=15.71; Pipe thickness:: x1.1; Model Number: Dra.no: 1; Layer number: 11; Length: 125.0 m; Main string number: 00; Dimension A: 300; Dimension B: 600; Height: 300; Width: 600; Project name: OpenBIM; Dimension R: 0; Dimension M: 0; Dimension F: 0; Tee dimension height: 0; Insulation k-value: 0; Pressure drop: 0; Insulation WSVO: 0; Flow (m\X\B3/h): 0.0 m\X\B3/h; Floor number: Storey: 2; Mtg. Above Slab ref Bottom: Edge= 2.85m SSL; Dimension E: 15; Outside dimension: 600.000000; Flow (l/h): 0.000000 l/h; Part number: .000; Room tekst: Hallway; Dimension DN: 600 x 300 mm; Above Sea Level ref. Bottom: NNUK=2.50 m; Room number: 00.02; X: X=22.58; Mtg. Below Ceiling ref Top: Top= 0.15m FCL; Rotation: 0.000000; Product Number: TPS0125; Building Part: Building: 0; Flow (l/s): 0.00 l/s; Medium: Extract Air; Abs. pressure: 0.0 Pa; Velocity: 0.00 m/s
AC_Pset_RenovationAndPhasing - Renovation Status: Existing

# IfcFlowFitting: TPS0140, Tee
In: 00 Ground floor
Type - Description: Collar Saddle, Circular D 140 mm; ApplicableOccurrence: Duct; PredefinedType: JUNCTION
Type - Pset_ManufacturerTypeInformation - ArticleNumber: TPS0140; ModelReference: Collar Saddle, Circular D 140 mm; Manufacturer: DDS; ModelLabel: GT
Type - Pset_DuctFittingTypeCommon - NominalDiameterOrWidth: 600, 140, 600; NominalHeight: 300, 140, 300
Material: IFC Building Material
Pset_DDS - Mounting Height: 3.00 m; Dimension L: 140; Tee dimension: 140; Above Sea Level ref. Center: NN=2.80 m; Dimension I: 0mm; Mtg. Below Ceiling ref Center: CC= 0.30m FCL; Rotation: 180.000000; Sub string number: .0030; Mtg. above Finished Floor ref Center: CC= 3.00m FFB; Manufacturer: DDS; Mtg. Above Slab ref Center: CC= 3.00m SSL; Ins thickness: ins= 0.000000 mm; Y: Y=15.71; Length: 140.0 m; Pipe thickness:: x1.1; Model Number: Dra.no: 1; Layer number: 11; Main string number: 00; Dimension A: 300; Dimension B: 600; Height: 300; Width: 600; Project name: OpenBIM; Dimension R: 0; Dimension M: 0; Dimension F: 0; Tee dimension height: 0; Insulation k-value: 0; Pressure drop: 0; Insulation WSVO: 0; Flow (m\X\B3/h): 0.0 m\X\B3/h; Floor number: Storey: 2; Room tekst: Hallway; Mtg. Above Slab ref Bottom: Edge= 2.85m SSL; Product Number: TPS0140; Dimension E: 15; Outside dimension: 600.000000; Flow (l/h): 0.000000 l/h; X: X=23.79; Part number: .000; Dimension DN: 600 x 300 mm; Above Sea Level ref. Bottom: NNUK=2.50 m; Room number: 00.03; Product: Collar Saddle, Circular D 140 mm; Mtg. Below Ceiling ref Top: Top= 0.15m FCL; Building Part: Building: 0; Flow (l/s): 0.00 l/s; Medium: Extract Air; Abs. pressure: 0.0 Pa; Velocity: 0.00 m/s
AC_Pset_RenovationAndPhasing - Renovation Status: Existing

# IfcFlowFitting: TPS0160 (5)
In: 00 Ground floor
Type - Description: Collar Saddle, Circular D 160 mm; ApplicableOccurrence: Duct; PredefinedType: JUNCTION
Type - Pset_ManufacturerTypeInformation - ArticleNumber: TPS0160; ModelReference: Collar Saddle, Circular D 160 mm; Manufacturer: DDS; ModelLabel: GT
Type - Pset_DuctFittingTypeCommon - NominalDiameterOrWidth: 400, 160, 400; NominalHeight: 200, 160, 200
Material: IFC Building Material; Group: Supply air
Pset_DDS - Dimension I: 0mm; Main string number: 01; Rotation: 179.999998; Manufacturer: DDS; Mounting Height: 3.15 m; Ins thickness: ins= 0.000000 mm; Mtg. Below Ceiling ref Top: Top= 0.25m FCL; System Name: Supply Air; Medium: Supply Air; Product Number: TPS0160; Pipe thickness:: x1.1; Length: 160.0 m; Model Number: Dra.no: 1; Layer number: 10; Dimension A: 200; Dimension B: 400; Height: 200; Width: 400; Sub string number: .0023; Project name: OpenBIM; Dimension R: 0; Dimension M: 0; Dimension F: 0; Tee dimension height: 0; Insulation k-value: 0; Pressure drop: 0; Insulation WSVO: 0; Floor number: Storey: 2; Mtg. above Finished Floor ref Center: CC= 3.15m FFB; Product: Collar Saddle, Circular D 160 mm; Mtg. Above Slab ref Bottom: Edge= 3.05m SSL; Above Sea Level ref. Center: NN=2.95 m; Dimension E: 15; Outside dimension: 400.000000; Mtg. Below Ceiling ref Center: CC= 0.35m FCL; Above Sea Level ref. Bottom: NNUK=2.75 m; Room tekst: Entrance; Dimension DN: 400 x 200 mm; Tee dimension: 160; Dimension L: 160; Room number: 00.01; Y: Y=8.14; Mtg. Above Slab ref Center: CC= 3.15m SSL; Building Part: Building: 0
AC_Pset_RenovationAndPhasing - Renovation Status: Existing
Name | Flow (l/s) | Flow (l/h) | Part number | Flow (m\X\B3/h) | Abs. pressure | Velocity | X
1.23.11 | 122.22 l/s | 440000.000000 l/h | .011 | 440.0 m\X\B3/h | 266.3 Pa | 1.15 m/s | X=26.31
1.23.13 | 91.67 l/s | 330000.000000 l/h | .013 | 330.0 m\X\B3/h | 265.9 Pa | 0.76 m/s | X=22.75
1.23.16 | 61.11 l/s | 220000.000000 l/h | .016 | 220.0 m\X\B3/h | 265.7 Pa | 0.38 m/s | X=19.19
1.23.19 | 30.56 l/s | 110000.000000 l/h | .019 | 110.0 m\X\B3/h | 265.7 Pa | 0.38 m/s | X=15.63
1.23.8 | 152.78 l/s | 550000.000000 l/h | .008 | 550.0 m\X\B3/h | 266.8 Pa | 1.53 m/s | X=29.87

# IfcFlowFitting: TPS0160, 1.23.0
In: 00 Ground floor
Type - Description: Collar Saddle, Circular D 160 mm; ApplicableOccurrence: Duct; PredefinedType: JUNCTION
Type - Pset_ManufacturerTypeInformation - ArticleNumber: TPS0160; ModelReference: Collar Saddle, Circular D 160 mm; Manufacturer: DDS; ModelLabel: GT
Type - Pset_DuctFittingTypeCommon - NominalDiameterOrWidth: 400, 160, 400; NominalHeight: 300, 160, 300
Material: IFC Building Material; Group: Supply air
Pset_DDS - Mounting Height: 3.00 m; Above Sea Level ref. Center: NN=2.80 m; Flow (l/s): 236.11 l/s; Mtg. Below Ceiling ref Center: CC= 0.43m FCL; Dimension I: 0mm; Rotation: 180.000000; Mtg. Above Slab ref Bottom: Edge= 2.72m SSL; Main string number: 01; Y: Y=9.28; Manufacturer: DDS; Ins thickness: ins= 0.000000 mm; Mtg. Below Ceiling ref Top: Top= 0.28m FCL; Mtg. above Finished Floor ref Center: CC= 2.87m FFB; System Name: Supply Air; Medium: Supply Air; Product Number: TPS0160; Pipe thickness:: x1.1; Flow (l/h): 850000.000000 l/h; Length: 160.0 m; Model Number: Dra.no: 1; Layer number: 10; Dimension A: 300; Dimension B: 400; Height: 300; Width: 400; Sub string number: .0023; Room number: 00.25; Flow (m\X\B3/h): 850.0 m\X\B3/h; Project name: OpenBIM; Dimension R: 0; Dimension M: 0; Dimension F: 0; Tee dimension height: 0; Insulation k-value: 0; Pressure drop: 0; Insulation WSVO: 0; Mtg. Above Slab ref Center: CC= 2.87m SSL; Floor number: Storey: 2; X: X=32.36; Product: Collar Saddle, Circular D 160 mm; Dimension E: 15; Outside dimension: 400.000000; Dimension DN: 400 x 300 mm; Part number: .000; Above Sea Level ref. Bottom: NNUK=2.50 m; Tee dimension: 160; Dimension L: 160; Velocity: 1.97 m/s; Room tekst: Director office; Building Part: Building: 0; Abs. pressure: 0.0 Pa
AC_Pset_RenovationAndPhasing - Renovation Status: Existing

# IfcFlowFitting: TPS0160 (7)
In: 01 First floor
Type - Description: Collar Saddle, Circular D 160 mm; ApplicableOccurrence: Duct; PredefinedType: JUNCTION
Type - Pset_ManufacturerTypeInformation - ArticleNumber: TPS0160; ModelReference: Collar Saddle, Circular D 160 mm; Manufacturer: DDS; ModelLabel: GT
Type - Pset_DuctFittingTypeCommon - NominalDiameterOrWidth: 600, 160, 600; NominalHeight: 300, 160, 300
Material: IFC Building Material; Group: Supply air
Pset_DDS - Mtg. Above Slab ref Center: CC= 3.12m SSL; Mounting Height: 3.00 m; Dimension I: 0mm; Main string number: 01; Sub string number: .0034; Manufacturer: DDS; Ins thickness: ins= 0.000000 mm; Above Sea Level ref. Bottom: NNUK=6.00 m; System Name: Supply Air; Above Sea Level ref. Center: NN=6.30 m; Medium: Supply Air; Product Number: TPS0160; Pipe thickness:: x1.1; Length: 160.0 m; Mtg. Below Ceiling ref Center: CC= 0.18m FCL; Model Number: Dra.no: 2; Layer number: 10; Dimension A: 300; Dimension B: 600; Height: 300; Width: 600; Project name: OpenBIM; Dimension R: 0; Dimension M: 0; Dimension F: 0; Tee dimension height: 0; Insulation k-value: 0; Pressure drop: 0; Insulation WSVO: 0; Floor number: Storey: 3; Product: Collar Saddle, Circular D 160 mm; Dimension E: 15; Outside dimension: 600.000000; Dimension DN: 600 x 300 mm; Y: Y=18.31; Tee dimension: 160; Dimension L: 160; Rotation: 0.000000; Building Part: Building: 0; Mtg. above Finished Floor ref Center: CC= 3.12m FFB; Mtg. Below Ceiling ref Top: Top= 0.03m FCL; Mtg. Above Slab ref Bottom: Edge= 2.97m SSL
AC_Pset_RenovationAndPhasing - Renovation Status: Existing
Name | Flow (m\X\B3/h) | X | Room number | Part number | Room tekst | Abs. pressure | Velocity | Flow (l/h) | Flow (l/s)
1.34.12 | 1400.0 m\X\B3/h | X=22.19 | 01.13 | .012 | Storage | 286.1 Pa | 1.85 m/s | 1400000.000000 l/h | 388.89 l/s
1.34.14 | 1200.0 m\X\B3/h | X=20.06 | 01.19 | .014 | Office | 285.8 Pa | 1.54 m/s | 1200000.000000 l/h | 333.33 l/s
1.34.16 | 1000.0 m\X\B3/h | X=18.19 | 01.19 | .016 | Office | 285.6 Pa | 1.23 m/s | 1000000.000000 l/h | 277.78 l/s
1.34.18 | 800.0 m\X\B3/h | X=15.56 | 01.20 | .018 | Office | 285.4 Pa | 0.93 m/s | 800000.000000 l/h | 222.22 l/s
1.34.20 | 600.0 m\X\B3/h | X=13.69 | 01.20 | .020 | Office | 285.3 Pa | 0.62 m/s | 600000.000000 l/h | 166.67 l/s
1.34.22 | 400.0 m\X\B3/h | X=11.41 | 01.18 | .022 | Office | 285.2 Pa | 0.31 m/s | 400000.000000 l/h | 111.11 l/s
1.34.24 | 200.0 m\X\B3/h | X=8.91 | 01.18 | .024 | Office | 285.2 Pa | 0.31 m/s | 200000.000000 l/h | 55.56 l/s

# IfcFlowFitting: TPS0250, Tee
In: 00 Ground floor
Type - Description: Collar Saddle, Circular D 250 mm; ApplicableOccurrence: Duct; PredefinedType: JUNCTION
Type - Pset_ManufacturerTypeInformation - ArticleNumber: TPS0250; ModelReference: Collar Saddle, Circular D 250 mm; Manufacturer: DDS; ModelLabel: GT
Type - Pset_DuctFittingTypeCommon - NominalDiameterOrWidth: 600, 250, 600; NominalHeight: 300, 250, 300
Material: IFC Building Material
Pset_DDS - Mounting Height: 3.00 m; Above Sea Level ref. Center: NN=2.80 m; Product: Collar Saddle, Circular D 250 mm; Dimension I: 0mm; Mtg. Below Ceiling ref Center: CC= 0.30m FCL; Rotation: 180.000000; Sub string number: .0030; Mtg. above Finished Floor ref Center: CC= 3.00m FFB; Manufacturer: DDS; Mtg. Above Slab ref Center: CC= 3.00m SSL; Ins thickness: ins= 0.000000 mm; Product Number: TPS0250; Y: Y=15.71; Length: 250.0 m; Pipe thickness:: x1.1; Model Number: Dra.no: 1; Layer number: 11; Main string number: 00; Dimension A: 300; Dimension B: 600; Height: 300; Width: 600; Project name: OpenBIM; Dimension R: 0; Dimension M: 0; Dimension F: 0; Tee dimension height: 0; Insulation k-value: 0; Pressure drop: 0; Insulation WSVO: 0; Flow (m\X\B3/h): 0.0 m\X\B3/h; Floor number: Storey: 2; Mtg. Above Slab ref Bottom: Edge= 2.85m SSL; X: X=20.21; Dimension E: 15; Tee dimension: 250; Dimension L: 250; Outside dimension: 600.000000; Flow (l/h): 0.000000 l/h; Part number: .000; Room tekst: Hallway; Dimension DN: 600 x 300 mm; Above Sea Level ref. Bottom: NNUK=2.50 m; Room number: 00.02; Mtg. Below Ceiling ref Top: Top= 0.15m FCL; Building Part: Building: 0; Flow (l/s): 0.00 l/s; Medium: Extract Air; Abs. pressure: 0.0 Pa; Velocity: 0.00 m/s
AC_Pset_RenovationAndPhasing - Renovation Status: Existing

# IfcFlowFitting: VK4205, 1.1.30
In: 00 Ground floor
Type - Description: Impeller water meter coldwater 3/4 Qn 2,5; ApplicableOccurrence: Basic
Type - Pset_ManufacturerTypeInformation - ArticleNumber: VK4205; ModelReference: Impeller water meter coldwater 3/4 Qn 2,5; Manufacturer: DDS
Material: IFC Building Material; Group: Coldwater
Pset_DDS - Mounting Height: 0.50 m; Pipe thickness:: x1.0; Above Sea Level ref. Center: NN=0.30 m; Product: Impeller water meter coldwater 3/4 Qn 2,5; Dimension DN: 20 mm; Mtg. Below Ceiling ref Center: CC= 2.93m FCL; Y: Y=10.62; Flow (l/h): 6731.999856 l/h; Main string number: 01; Manufacturer: DDS; Product Number: VK4205; X: X=29.67; Ins thickness: ins= 9.000000 mm; Room tekst: FB; Mtg. above Finished Floor ref Center: CC= 0.37m FFB; System Name: PW; Room number: 00.15; Model Number: Dra.no: 1; Mtg. Above Slab ref Bottom: Edge= 0.36m SSL; Layer number: 2; Width: 20; Length: 130.0 m; Project name: OpenBIM; Height: 0; Insulation k-value: 0; Insulation WSVO: 0; Outside dimension: 22.000000; Mtg. Above Slab ref Center: CC= 0.37m SSL; Flow (m\X\B3/h): 6.7 m\X\B3/h; Floor number: Storey: 2; Velocity: 2.31 m/s; Mtg. Below Ceiling ref Top: Top= 2.92m FCL; Pressure drop: 106751; Part number: .030; Insulation product text: Pipe insulation; Sub string number: .0001; Flow (l/s): 1.87 l/s; Above Sea Level ref. Bottom: NNUK=0.28 m; Rotation: 0.000000; Building Part: Building: 0; Medium: Coldwater; Abs. pressure: 351157.7 Pa; Insulation product number: ZP150/922
AC_Pset_RenovationAndPhasing - Renovation Status: Existing

# IfcFlowFitting: ZZSSBE (6)
In: 01 First floor
Type - Description: Steel construction bend; ApplicableOccurrence: Basic; PredefinedType: BEND
Type - Pset_ManufacturerTypeInformation - ArticleNumber: ZZSSBE; ModelReference: Steel construction bend; Manufacturer: DDS
Type - Pset_PipeFittingTypeCommon - SubType: Bend 90 degree; NominalDiameter: 15; InnerDiameter: 15; OuterDiameter: 15
Material: IFC Building Material
Pset_DDS - Product Number: ZZSSBE; Manufacturer: DDS; Rotation: 270.000000; Ins thickness: ins= 0.000000 mm; Product: Steel construction bend; Room tekst: Office; Room number: 01.17; Model Number: Dra.no: 2; Main string number: 00; Project name: OpenBIM; Height: 0; Insulation k-value: 0; Pressure drop: 0; Insulation WSVO: 0; Flow (m\X\B3/h): 0.0 m\X\B3/h; Floor number: Storey: 3; Width: 15; Flow (l/h): 0.000000 l/h; Length: 90.0 m; Pipe thickness:: x0.0; Part number: .000; Outside dimension: 15.000000; Sub string number: .0000; Dimension DN: 15 mm; Building Part: Building: 0; Flow (l/s): 0.00 l/s; Abs. pressure: 0.0 Pa; Velocity: 0.00 m/s
AC_Pset_RenovationAndPhasing - Renovation Status: Existing
Name | Mtg. Above Slab ref Bottom | Mtg. above Finished Floor ref Center | X | Mtg. Above Slab ref Center | Y | Mtg. Below Ceiling ref Top | Mtg. Below Ceiling ref Center | Layer number | Mounting Height | Above Sea Level ref. Bottom | Medium | Above Sea Level ref. Center
Bend | Edge= -0.05m SSL | CC= -0.04m FFB | X=5.36 | CC= -0.04m SSL | Y=12.27 | Top= 3.33m FCL | CC= 3.34m FCL | 6 | 0.09 m | NNUK=3.38 m | Heat return | NN=3.39 m
Bend | Edge= -0.05m SSL | CC= -0.04m FFB | X=5.25 | CC= -0.04m SSL | Y=12.27 | Top= 3.33m FCL | CC= 3.34m FCL | 6 | 0.09 m | NNUK=3.38 m | Heat return | NN=3.39 m
Bend | Edge= -0.34m SSL | CC= -0.33m FFB | X=5.25 | CC= -0.33m SSL | Y=12.27 | Top= 3.62m FCL | CC= 3.63m FCL | 6 | -0.20 m | NNUK=3.09 m | Heat return | NN=3.10 m
Bend | Edge= -0.24m SSL | CC= -0.23m FFB | X=5.25 | CC= -0.23m SSL | Y=12.22 | Top= 3.52m FCL | CC= 3.53m FCL | 5 | -0.10 m | NNUK=3.19 m | Heat flow | NN=3.20 m
Bend | Edge= -0.05m SSL | CC= -0.04m FFB | X=5.25 | CC= -0.04m SSL | Y=12.22 | Top= 3.33m FCL | CC= 3.34m FCL | 5 | 0.09 m | NNUK=3.38 m | Heat flow | NN=3.39 m
Bend | Edge= -0.05m SSL | CC= -0.04m FFB | X=5.36 | CC= -0.04m SSL | Y=12.22 | Top= 3.33m FCL | CC= 3.34m FCL | 5 | 0.09 m | NNUK=3.38 m | Heat flow | NN=3.39 m

# IfcFlowSegment: GT-20130816-001, 01.0004.01
In: 00 Ground floor
Type - Description: Ventilation Duct galvanised Steel Sheet - Flange Connection 1; ApplicableOccurrence: Duct; PredefinedType: RIGIDSEGMENT
Type - Pset_ManufacturerTypeInformation - ArticleNumber: GT-20130816-001; ModelReference: Ventilation Duct galvanised Steel Sheet - Flange Connection 1; Manufacturer: DDS
Type - Pset_DuctSegmentTypeCommon - NominalDiameterOrWidth: 200; NominalHeight: 300
Material: ML-Ventilation Duct galvanised Steel Sheet - Flange Connection 1; Group: Supply air
Pset_DDS - Above Sea Level ref. Bottom: NNUK=2.65 m; Mounting Height: 3.00 m; Above Sea Level ref. Center: NN=2.80 m; Mtg. Below Ceiling ref Center: CC= 0.30m FCL; X: X=31.76; Main string number: 01; Mtg. above Finished Floor ref Center: CC= 3.00m FFB; Manufacturer: DDS; Mtg. Above Slab ref Center: CC= 3.00m SSL; Iso thickness: iso= 0.000000 mm; System Name: Supply Air; Part number: .001; Medium: Supply Air; Flowsegment thickness: x1.1; Model Number: Dra.no: 1; Product Number: GT-20130816-001; Layer number: 10; Height: 300; Width: 200; Project name: OpenBIM; Length: 7; Insulation WSVO: 0; Insulation k-value: 0; Abs. pressure: 208.5 Pa; Floor number: Storey: 2; Room tekst: Hallway; Mtg. Above Slab ref Bottom: Edge= 2.85m SSL; Y: Y=18.32; Sub string number: .0004; Room number: 00.03; Dimension DN: 200 x 300 mm; Product: Ventilation Duct galvanised Steel Sheet - Flange Connection 1; Mtg. Below Ceiling ref Top: Top= 0.15m FCL; Velocity: 10.19 m/s; Building Part: Building: 0; Flow: 2200.0 m\X\B3/h
Pset_FlowSegmentDuctSegment - Length: 6509.92 mm
AC_Pset_RenovationAndPhasing - Renovation Status: Existing

# IfcFlowSegment: GT-20130816-001 (4)
In: 00 Ground floor
Type - Description: Ventilation Duct galvanised Steel Sheet - Flange Connection 1; ApplicableOccurrence: Duct; PredefinedType: RIGIDSEGMENT
Type - Pset_ManufacturerTypeInformation - ArticleNumber: GT-20130816-001; ModelReference: Ventilation Duct galvanised Steel Sheet - Flange Connection 1; Manufacturer: DDS
Type - Pset_DuctSegmentTypeCommon - NominalDiameterOrWidth: 300; NominalHeight: 300
Material: ML-Ventilation Duct galvanised Steel Sheet - Flange Connection 1; Group: Supply air
Pset_DDS - Above Sea Level ref. Bottom: NNUK=2.65 m; Mounting Height: 3.00 m; Above Sea Level ref. Center: NN=2.80 m; Main string number: 01; Manufacturer: DDS; Iso thickness: iso= 0.000000 mm; System Name: Supply Air; Medium: Supply Air; Flowsegment thickness: x1.1; Model Number: Dra.no: 1; Product Number: GT-20130816-001; Layer number: 10; Height: 300; Width: 300; Project name: OpenBIM; Insulation WSVO: 0; Insulation k-value: 0; Floor number: Storey: 2; Dimension DN: 300 x 300 mm; Product: Ventilation Duct galvanised Steel Sheet - Flange Connection 1; Building Part: Building: 0
AC_Pset_RenovationAndPhasing - Renovation Status: Existing
Name | Pset_FlowSegmentDuctSegment, Length (mm) | Velocity | Mtg. Below Ceiling ref Center | Mtg. above Finished Floor ref Center | Y | Mtg. Above Slab ref Center | Part number | X | Pset_DDS, Length | Flow | Room tekst | Mtg. Above Slab ref Bottom | Abs. pressure | Sub string number | Room number | Mtg. Below Ceiling ref Top
01.0003.01 | 4692.01 | 8.12 m/s | CC= 0.30m FCL | CC= 3.00m FFB | Y=13.33 | CC= 3.00m SSL | .001 | X=32.41 | 5 | 2632.0 m\X\B3/h | Hallway | Edge= 2.85m SSL | 263.4 Pa | .0003 | 00.03 | Top= 0.15m FCL
01.0018.01 | 277.892 | 1.33 m/s | CC= 0.30m FCL | CC= 3.00m FFB | Y=18.27 | CC= 3.00m SSL | .001 | X=32.96 | 0 | 432.0 m\X\B3/h | Hallway | Edge= 2.85m SSL | 225.7 Pa | .0018 | 00.03 | Top= 0.15m FCL
01.0018.02 | 1735.59 | 1.33 m/s | CC= 0.30m FCL | CC= 3.00m FFB | Y=18.27 | CC= 3.00m SSL | .002 | X=33.23 | 2 | 432.0 m\X\B3/h | Hallway | Edge= 2.85m SSL | 225.6 Pa | .0018 | 00.03 | Top= 0.15m FCL
01.0018.04 | 217.926 | 0.67 m/s | CC= 0.18m FCL | CC= 3.12m FFB | Y=18.27 | CC= 3.12m SSL | .004 | X=34.97 | 1 | 216.0 m\X\B3/h | Office | Edge= 2.97m SSL | 225.4 Pa | .0018 | 00.23 | Top= 0.03m FCL

# IfcFlowSegment: GT-20130816-001 (6)
In: 00 Ground floor
Type - Description: Ventilation Duct galvanised Steel Sheet - Flange Connection 1; ApplicableOccurrence: Duct; PredefinedType: RIGIDSEGMENT
Type - Pset_ManufacturerTypeInformation - ArticleNumber: GT-20130816-001; ModelReference: Ventilation Duct galvanised Steel Sheet - Flange Connection 1; Manufacturer: DDS
Type - Pset_DuctSegmentTypeCommon - NominalDiameterOrWidth: 400; NominalHeight: 200
Material: ML-Ventilation Duct galvanised Steel Sheet - Flange Connection 1; Group: Supply air
Pset_DDS - Main string number: 01; Above Sea Level ref. Bottom: NNUK=2.85 m; Manufacturer: DDS; Mounting Height: 3.15 m; Iso thickness: iso= 0.000000 mm; System Name: Supply Air; Medium: Supply Air; Flowsegment thickness: x1.1; Model Number: Dra.no: 1; Product Number: GT-20130816-001; Layer number: 10; Height: 200; Width: 400; Sub string number: .0023; Project name: OpenBIM; Insulation WSVO: 0; Insulation k-value: 0; Floor number: Storey: 2; Above Sea Level ref. Center: NN=2.95 m; Dimension DN: 400 x 200 mm; Y: Y=8.14; Product: Ventilation Duct galvanised Steel Sheet - Flange Connection 1; Building Part: Building: 0
AC_Pset_RenovationAndPhasing - Renovation Status: Existing
Name | Pset_FlowSegmentDuctSegment, Length (mm) | Mtg. Above Slab ref Center | Mtg. Above Slab ref Bottom | Mtg. Below Ceiling ref Center | Room number | Flow | Pset_DDS, Length | Velocity | Part number | X | Abs. pressure | Room tekst | Mtg. Below Ceiling ref Top | Mtg. above Finished Floor ref Center
01.0023.07 | 1453.16 | CC= 3.02m SSL | Edge= 2.92m SSL | CC= 0.28m FCL | 00.25 | 550.0 m\X\B3/h | 1 | 1.91 m/s | .007 | X=31.32 | 267.2 Pa | Director office | Top= 0.18m FCL | CC= 3.02m FFB
01.0023.08 | 3560.45 | CC= 3.15m SSL | Edge= 3.05m SSL | CC= 0.35m FCL | 00.01 | 440.0 m\X\B3/h | 2 | 1.53 m/s | .008 | X=29.87 | 266.8 Pa | Entrance | Top= 0.25m FCL | CC= 3.15m FFB
01.0023.11 | 3560.45 | CC= 3.15m SSL | Edge= 3.05m SSL | CC= 0.35m FCL | 00.01 | 330.0 m\X\B3/h | 2 | 1.15 m/s | .011 | X=26.31 | 266.3 Pa | Entrance | Top= 0.25m FCL | CC= 3.15m FFB
01.0023.13 | 3560.45 | CC= 3.15m SSL | Edge= 3.05m SSL | CC= 0.35m FCL | 00.01 | 220.0 m\X\B3/h | 2 | 0.76 m/s | .013 | X=22.75 | 265.9 Pa | Entrance | Top= 0.25m FCL | CC= 3.15m FFB
01.0023.16 | 3560.45 | CC= 3.15m SSL | Edge= 3.05m SSL | CC= 0.35m FCL | 00.01 | 110.0 m\X\B3/h | 2 | 0.38 m/s | .016 | X=19.19 | 265.7 Pa | Entrance | Top= 0.25m FCL | CC= 3.15m FFB
01.0023.19 | 292.337 | CC= 3.15m SSL | Edge= 3.05m SSL | CC= 0.35m FCL | 00.01 | 0.0 m\X\B3/h | 1 | 0.00 m/s | .019 | X=15.63 | 265.7 Pa | Entrance | Top= 0.25m FCL | CC= 3.15m FFB

# IfcFlowSegment: GT-20130816-001 (3)
In: 00 Ground floor
Type - Description: Ventilation Duct galvanised Steel Sheet - Flange Connection 1; ApplicableOccurrence: Duct; PredefinedType: RIGIDSEGMENT
Type - Pset_ManufacturerTypeInformation - ArticleNumber: GT-20130816-001; ModelReference: Ventilation Duct galvanised Steel Sheet - Flange Connection 1; Manufacturer: DDS
Type - Pset_DuctSegmentTypeCommon - NominalDiameterOrWidth: 400; NominalHeight: 300
Material: ML-Ventilation Duct galvanised Steel Sheet - Flange Connection 1; Group: Supply air
Pset_DDS - Above Sea Level ref. Bottom: NNUK=2.65 m; Mounting Height: 3.00 m; Above Sea Level ref. Center: NN=2.80 m; Main string number: 01; Manufacturer: DDS; Iso thickness: iso= 0.000000 mm; System Name: Supply Air; Medium: Supply Air; Flowsegment thickness: x1.1; Model Number: Dra.no: 1; Product Number: GT-20130816-001; Layer number: 10; Height: 300; Width: 400; Sub string number: .0023; Flow: 850.0 m\X\B3/h; Project name: OpenBIM; Insulation WSVO: 0; Insulation k-value: 0; Floor number: Storey: 2; Abs. pressure: 269.8 Pa; Dimension DN: 400 x 300 mm; Velocity: 1.97 m/s; Product: Ventilation Duct galvanised Steel Sheet - Flange Connection 1; Building Part: Building: 0
AC_Pset_RenovationAndPhasing - Renovation Status: Existing
Name | Pset_FlowSegmentDuctSegment, Length (mm) | Mtg. Below Ceiling ref Center | Mtg. above Finished Floor ref Center | Mtg. Above Slab ref Center | Y | Part number | Pset_DDS, Length | X | Room tekst | Mtg. Above Slab ref Bottom | Room number | Mtg. Below Ceiling ref Top
01.0023.02 | 2852.24 | CC= 0.30m FCL | CC= 3.00m FFB | CC= 3.00m SSL | Y=12.13 | .002 | 3 | X=32.36 | Hallway | Edge= 2.85m SSL | 00.03 | Top= 0.15m FCL
01.0023.02 | 840.726 | CC= 0.43m FCL | CC= 2.87m FFB | CC= 2.87m SSL | Y=9.28 | .002 | 2 | X=32.36 | Director office | Edge= 2.72m SSL | 00.25 | Top= 0.28m FCL
01.0023.05 | 564.265 | CC= 0.43m FCL | CC= 2.87m FFB | CC= 2.87m SSL | Y=8.14 | .005 | 1 | X=32.06 | Director office | Edge= 2.72m SSL | 00.25 | Top= 0.28m FCL

# IfcFlowSegment: GT-20130816-001 (20)
Type - Description: Ventilation Duct galvanised Steel Sheet - Flange Connection 1; ApplicableOccurrence: Duct; PredefinedType: RIGIDSEGMENT
Type - Pset_ManufacturerTypeInformation - ArticleNumber: GT-20130816-001; ModelReference: Ventilation Duct galvanised Steel Sheet - Flange Connection 1; Manufacturer: DDS
Type - Pset_DuctSegmentTypeCommon - NominalDiameterOrWidth: 600; NominalHeight: 300
Material: ML-Ventilation Duct galvanised Steel Sheet - Flange Connection 1
Pset_DDS - Mounting Height: 3.00 m; Manufacturer: DDS; Iso thickness: iso= 0.000000 mm; Flowsegment thickness: x1.1; Product Number: GT-20130816-001; Height: 300; Width: 600; Project name: OpenBIM; Insulation WSVO: 0; Insulation k-value: 0; Dimension DN: 600 x 300 mm; Product: Ventilation Duct galvanised Steel Sheet - Flange Connection 1; Building Part: Building: 0
AC_Pset_RenovationAndPhasing - Renovation Status: Existing
Name | In | Above Sea Level ref. Bottom | Above Sea Level ref. Center | Y | Mtg. Below Ceiling ref Center | Main string number | Mtg. above Finished Floor ref Center | Flow | Mtg. Above Slab ref Center | X | System Name | Medium | Model Number | Layer number | Velocity | Pset_DDS, Length | Abs. pressure | Floor number | Mtg. Above Slab ref Bottom | Sub string number | Part number | Mtg. Below Ceiling ref Top | Pset_FlowSegmentDuctSegment, Length (mm) | Group | Room number | Room tekst
01.0002.05 | 00 Ground floor | NNUK=2.65 m | NN=2.80 m | Y=12.83 | CC= 0.50m FCL | 01 | CC= 3.00m FFB | 3482.0 m\X\B3/h | CC= 3.00m SSL | X=31.00 | Supply Air | Supply Air | Dra.no: 1 | 10 | 2.69 m/s | 1 | 300.7 Pa | Storey: 2 | Edge= 2.85m SSL | .0002 | .005 | Top= 0.00m FCL | 1057.4 | Supply air
01.0034.01 | 01 First floor | NNUK=6.15 m | NN=6.30 m | Y=12.83 | CC= 0.30m FCL | 01 | CC= 3.00m FFB | 1400.0 m\X\B3/h | CC= 3.00m SSL | X=31.05 | Supply Air | Supply Air | Dra.no: 2 | 10 | 2.16 m/s | 1 | 293.9 Pa | Storey: 3 | Edge= 2.85m SSL | .0034 | .001 | Top= 0.00m FCL | 1495.88 | Supply air
01.0034.03 | 01 First floor | NNUK=6.15 m | NN=6.30 m | Y=13.23 | CC= 0.43m FCL | 01 | CC= 2.87m FFB | 1400.0 m\X\B3/h | CC= 2.87m SSL | X=32.95 | Supply Air | Supply Air | Dra.no: 2 | 10 | 2.16 m/s | 5 | 293.9 Pa | Storey: 3 | Edge= 2.72m SSL | .0034 | .003 | Top= 0.28m FCL | 4680.63 | Supply air | 01.02 | Hallway
01.0034.07 | 01 First floor | NNUK=6.15 m | NN=6.30 m | Y=18.31 | CC= 0.43m FCL | 01 | CC= 2.87m FFB | 1400.0 m\X\B3/h | CC= 2.87m SSL | X=32.55 | Supply Air | Supply Air | Dra.no: 2 | 10 | 2.16 m/s | 8 | 293.9 Pa | Storey: 3 | Edge= 2.72m SSL | .0034 | .007 | Top= 0.28m FCL | 8069.92 | Supply air | 01.02 | Hallway
01.0034.11 | 01 First floor | NNUK=6.15 m | NN=6.30 m | Y=18.31 | CC= 0.43m FCL | 01 | CC= 2.87m FFB | 1400.0 m\X\B3/h | CC= 2.87m SSL | X=24.48 | Supply Air | Supply Air | Dra.no: 2 | 10 | 2.16 m/s | 2 | 286.5 Pa | Storey: 3 | Edge= 2.72m SSL | .0034 | .011 | Top= 0.28m FCL | 2287.76 | Supply air | 01.02 | Hallway
01.0034.13 | 01 First floor | NNUK=6.15 m | NN=6.30 m | Y=18.31 | CC= 0.18m FCL | 01 | CC= 3.12m FFB | 1200.0 m\X\B3/h | CC= 3.12m SSL | X=22.19 | Supply Air | Supply Air | Dra.no: 2 | 10 | 1.85 m/s | 2 | 286.1 Pa | Storey: 3 | Edge= 2.97m SSL | .0034 | .013 | Top= 0.03m FCL | 2125 | Supply air | 01.13 | Storage
01.0034.15 | 01 First floor | NNUK=6.15 m | NN=6.30 m | Y=18.31 | CC= 0.18m FCL | 01 | CC= 3.12m FFB | 1000.0 m\X\B3/h | CC= 3.12m SSL | X=20.06 | Supply Air | Supply Air | Dra.no: 2 | 10 | 1.54 m/s | 2 | 285.8 Pa | Storey: 3 | Edge= 2.97m SSL | .0034 | .015 | Top= 0.03m FCL | 1875 | Supply air | 01.19 | Office
01.0034.17 | 01 First floor | NNUK=6.15 m | NN=6.30 m | Y=18.31 | CC= 0.18m FCL | 01 | CC= 3.12m FFB | 800.0 m\X\B3/h | CC= 3.12m SSL | X=18.19 | Supply Air | Supply Air | Dra.no: 2 | 10 | 1.23 m/s | 2 | 285.6 Pa | Storey: 3 | Edge= 2.97m SSL | .0034 | .017 | Top= 0.03m FCL | 2625 | Supply air | 01.19 | Office
01.0034.19 | 01 First floor | NNUK=6.15 m | NN=6.30 m | Y=18.31 | CC= 0.18m FCL | 01 | CC= 3.12m FFB | 600.0 m\X\B3/h | CC= 3.12m SSL | X=15.56 | Supply Air | Supply Air | Dra.no: 2 | 10 | 0.93 m/s | 2 | 285.4 Pa | Storey: 3 | Edge= 2.97m SSL | .0034 | .019 | Top= 0.03m FCL | 1875 | Supply air | 01.20 | Office
01.0034.21 | 01 First floor | NNUK=6.15 m | NN=6.30 m | Y=18.31 | CC= 0.18m FCL | 01 | CC= 3.12m FFB | 400.0 m\X\B3/h | CC= 3.12m SSL | X=13.69 | Supply Air | Supply Air | Dra.no: 2 | 10 | 0.62 m/s | 2 | 285.3 Pa | Storey: 3 | Edge= 2.97m SSL | .0034 | .021 | Top= 0.03m FCL | 2280 | Supply air | 01.20 | Office
01.0034.23 | 01 First floor | NNUK=6.15 m | NN=6.30 m | Y=18.31 | CC= 0.18m FCL | 01 | CC= 3.12m FFB | 200.0 m\X\B3/h | CC= 3.12m SSL | X=11.41 | Supply Air | Supply Air | Dra.no: 2 | 10 | 0.31 m/s | 2 | 285.2 Pa | Storey: 3 | Edge= 2.97m SSL | .0034 | .023 | Top= 0.03m FCL | 2500 | Supply air | 01.18 | Office
01.0034.25 | 01 First floor | NNUK=6.15 m | NN=6.30 m | Y=18.31 | CC= 0.18m FCL | 01 | CC= 3.12m FFB | 0.0 m\X\B3/h | CC= 3.12m SSL | X=8.91 | Supply Air | Supply Air | Dra.no: 2 | 10 | 0.00 m/s | 1 | 285.2 Pa | Storey: 3 | Edge= 2.97m SSL | .0034 | .025 | Top= 0.03m FCL | 698.885 | Supply air | 01.18 | Office
Duct | 00 Ground floor | NNUK=2.65 m | NN=2.80 m | Y=16.64 | CC= 0.30m FCL | 00 | CC= 3.00m FFB | 0.0 m\X\B3/h | CC= 3.00m SSL | X=25.24 |  | Extract Air | Dra.no: 1 | 11 | 0.00 m/s | 1 | 0.0 Pa | Storey: 2 | Edge= 2.85m SSL | .0000 | .000 | Top= 0.15m FCL | 525.795 |  | 00.03 | Hallway
Duct | 00 Ground floor | NNUK=2.65 m | NN=2.80 m | Y=15.71 | CC= 0.30m FCL | 00 | CC= 3.00m FFB | 0.0 m\X\B3/h | CC= 3.00m SSL | X=24.84 |  | Extract Air | Dra.no: 1 | 11 | 0.00 m/s | 1 | 0.0 Pa | Storey: 2 | Edge= 2.85m SSL | .0000 | .000 | Top= 0.15m FCL | 1051.68 |  | 00.03 | Hallway
Duct | 00 Ground floor | NNUK=2.65 m | NN=2.80 m | Y=15.71 | CC= 0.30m FCL | 00 | CC= 3.00m FFB | 0.0 m\X\B3/h | CC= 3.00m SSL | X=23.79 |  | Extract Air | Dra.no: 1 | 11 | 0.00 m/s | 2 | 0.0 Pa | Storey: 2 | Edge= 2.85m SSL | .0000 | .000 | Top= 0.15m FCL | 1208.76 |  | 00.03 | Hallway
Duct | 00 Ground floor | NNUK=2.65 m | NN=2.80 m | Y=15.71 | CC= 0.30m FCL | 00 | CC= 3.00m FFB | 0.0 m\X\B3/h | CC= 3.00m SSL | X=22.58 |  | Extract Air | Dra.no: 1 | 11 | 0.00 m/s | 2 | 0.0 Pa | Storey: 2 | Edge= 2.85m SSL | .0000 | .000 | Top= 0.15m FCL | 2362.67 |  | 00.02 | Hallway
Duct | 00 Ground floor | NNUK=2.65 m | NN=2.80 m | Y=15.71 | CC= 0.30m FCL | 00 | CC= 3.00m FFB | 0.0 m\X\B3/h | CC= 3.00m SSL | X=20.21 |  | Extract Air | Dra.no: 1 | 11 | 0.00 m/s | 1 | 0.0 Pa | Storey: 2 | Edge= 2.85m SSL | .0000 | .000 | Top= 0.15m FCL | 628.679 |  | 00.02 | Hallway
Duct | 00 Ground floor | NNUK=2.65 m | NN=2.80 m | Y=13.73 | CC= 0.50m FCL | 00 | CC= 3.00m FFB | 0.0 m\X\B3/h | CC= 3.00m SSL | X=31.00 |  | Extract Air | Dra.no: 1 | 11 | 0.00 m/s | 0 | 0.0 Pa | Storey: 2 | Edge= 2.85m SSL | .0000 | .000 | Top= 0.00m FCL | 298.616
Duct | 00 Ground floor | NNUK=2.65 m | NN=2.80 m | Y=14.13 | CC= 0.30m FCL | 00 | CC= 3.00m FFB | 0.0 m\X\B3/h | CC= 3.00m SSL | X=31.70 |  | Extract Air | Dra.no: 1 | 11 | 0.00 m/s | 3 | 0.0 Pa | Storey: 2 | Edge= 2.85m SSL | .0000 | .000 | Top= 0.15m FCL | 2515.48 |  | 00.03 | Hallway
Duct | 00 Ground floor | NNUK=2.65 m | NN=2.80 m | Y=17.04 | CC= 0.30m FCL | 00 | CC= 3.00m FFB | 0.0 m\X\B3/h | CC= 3.00m SSL | X=31.30 |  | Extract Air | Dra.no: 1 | 11 | 0.00 m/s | 6 | 0.0 Pa | Storey: 2 | Edge= 2.85m SSL | .0000 | .000 | Top= 0.15m FCL | 5661.17 |  | 00.03 | Hallway

# IfcFlowSegment: GT-20130816-001 (19)
Type - Description: Ventilation Duct galvanised Steel Sheet - Flange Connection 1; ApplicableOccurrence: Duct; PredefinedType: RIGIDSEGMENT
Type - Pset_ManufacturerTypeInformation - ArticleNumber: GT-20130816-001; ModelReference: Ventilation Duct galvanised Steel Sheet - Flange Connection 1; Manufacturer: DDS
Type - Pset_DuctSegmentTypeCommon - NominalDiameterOrWidth: 600; NominalHeight: 600
Material: ML-Ventilation Duct galvanised Steel Sheet - Flange Connection 1
Pset_DDS - Manufacturer: DDS; Iso thickness: iso= 0.000000 mm; Flowsegment thickness: x1.1; Product Number: GT-20130816-001; Width: 600; Height: 600; Project name: OpenBIM; Insulation WSVO: 0; Insulation k-value: 0; Dimension DN: 600 x 600 mm; Product: Ventilation Duct galvanised Steel Sheet - Flange Connection 1; Building Part: Building: 0
AC_Pset_RenovationAndPhasing - Renovation Status: Existing
Name | In | Pset_FlowSegmentDuctSegment, Length (mm) | Y | X | Main string number | Flow | Mounting Height | System Name | Part number | Medium | Model Number | Layer number | Velocity | Pset_DDS, Length | Abs. pressure | Floor number | Mtg. above Finished Floor ref Center | Mtg. Above Slab ref Bottom | Above Sea Level ref. Center | Mtg. Below Ceiling ref Center | Sub string number | Above Sea Level ref. Bottom | Mtg. Above Slab ref Center | Mtg. Below Ceiling ref Top | Group | Room tekst | Room number
01.0002.01 | 01 First floor | 3050 | Y=12.83 | X=30.60 | 01 | 3482.0 m\X\B3/h | 2.75 m | Supply Air | .001 | Supply Air | Dra.no: 2 | 10 | 2.69 m/s | 3 | 301.1 Pa | Storey: 3 | CC= 2.75m FFB | Edge= 2.45m SSL | NN=6.05 m | CC= 0.55m FCL | .0002 | NNUK=5.75 m | CC= 2.75m SSL | Top= 0.00m FCL | Supply air
01.0000.01 | 02 Second floor | 1350 | Y=16.46 | X=17.63 | 01 | 0.0 m\X\B3/h | 1.90 m |  | .001 | Exhaust air | Dra.no: 3 | 14 | 0.00 m/s | 1 | 0.0 Pa | Storey: 4 | CC= 1.77m FFB | Edge= 1.47m SSL | NN=8.70 m | CC= 1.53m FCL | .0000 | NNUK=8.40 m | CC= 1.77m SSL | Top= 1.23m FCL | Exhaust air | Installation space | 02.04
01.0000.01 | 02 Second floor | 64.2827 | Y=16.00 | X=17.63 | 01 | 0.0 m\X\B3/h | 1.50 m |  | .001 | Exhaust air | Dra.no: 3 | 14 | 0.00 m/s | 0 | 0.0 Pa | Storey: 4 | CC= 1.37m FFB | Edge= 1.07m SSL | NN=8.30 m | CC= 1.93m FCL | .0000 | NNUK=8.00 m | CC= 1.37m SSL | Top= 1.63m FCL | Exhaust air | Installation space | 02.04
01.0001.01 | 02 Second floor | 58.6822 | Y=12.00 | X=17.63 | 01 | 4882.0 m\X\B3/h | 0.50 m | Supply Air | .001 | Supply Air | Dra.no: 3 | 10 | 3.77 m/s | 0 | 356.6 Pa | Storey: 4 | CC= 0.37m FFB | Edge= 0.07m SSL | NN=7.30 m | CC= 2.93m FCL | .0001 | NNUK=7.00 m | CC= 0.37m SSL | Top= 2.63m FCL | Supply air | Installation space | 02.04
01.0001.03 | 02 Second floor | 1483.57 | Y=11.54 | X=18.03 | 01 | 4882.0 m\X\B3/h | 0.50 m | Supply Air | .003 | Supply Air | Dra.no: 3 | 10 | 3.77 m/s | 1 | 356.6 Pa | Storey: 4 | CC= 0.37m FFB | Edge= 0.07m SSL | NN=7.30 m | CC= 2.93m FCL | .0001 | NNUK=7.00 m | CC= 0.37m SSL | Top= 2.63m FCL | Supply air | Installation space | 02.04
01.0001.07 | 02 Second floor | 1600 | Y=11.90 | X=20.04 | 01 | 4882.0 m\X\B3/h | 0.90 m | Supply Air | .007 | Supply Air | Dra.no: 3 | 10 | 3.77 m/s | 2 | 356.6 Pa | Storey: 4 | CC= 0.77m FFB | Edge= 0.47m SSL | NN=7.70 m | CC= 2.53m FCL | .0001 | NNUK=7.40 m | CC= 0.77m SSL | Top= 2.23m FCL | Supply air | Installation space | 02.04
01.0001.09 | 02 Second floor | 743.48 | Y=12.19 | X=20.32 | 01 | 4882.0 m\X\B3/h | 2.90 m | Supply Air | .009 | Supply Air | Dra.no: 3 | 10 | 3.77 m/s | 1 | 356.6 Pa | Storey: 4 | CC= 2.77m FFB | Edge= 2.47m SSL | NN=9.70 m | CC= 0.53m FCL | .0001 | NNUK=9.40 m | CC= 2.77m SSL | Top= 0.23m FCL | Supply air | Installation space | 02.04
01.0001.11 | 02 Second floor | 9066.82 | Y=12.83 | X=21.13 | 01 | 4882.0 m\X\B3/h | 2.90 m | Supply Air | .011 | Supply Air | Dra.no: 3 | 10 | 3.77 m/s | 9 | 356.6 Pa | Storey: 4 | CC= 2.77m FFB | Edge= 2.47m SSL | NN=9.70 m | CC= 0.53m FCL | .0001 | NNUK=9.40 m | CC= 2.77m SSL | Top= 0.23m FCL | Supply air | Installation space | 02.04
01.0001.17 | 02 Second floor | 2550 | Y=12.83 | X=30.60 | 01 | 4882.0 m\X\B3/h | 2.50 m | Supply Air | .017 | Supply Air | Dra.no: 3 | 10 | 3.77 m/s | 3 | 356.6 Pa | Storey: 4 | CC= 2.50m FFB | Edge= 2.20m SSL | NN=9.30 m | CC= 0.80m FCL | .0001 | NNUK=9.00 m | CC= 2.50m SSL | Top= 0.00m FCL | Supply air
02.0000.01 | 02 Second floor | 10614.1 | Y=13.73 | X=19.58 | 02 | 0.0 m\X\B3/h | 2.90 m | Extract air | .001 | Extract Air | Dra.no: 3 | 11 | 0.00 m/s | 11 | 0.0 Pa | Storey: 4 | CC= 2.77m FFB | Edge= 2.47m SSL | NN=9.70 m | CC= 0.53m FCL | .0000 | NNUK=9.40 m | CC= 2.77m SSL | Top= 0.23m FCL | Extract air | Installation space | 02.04
02.0000.01 | 02 Second floor | 2550 | Y=13.73 | X=30.60 | 02 | 0.0 m\X\B3/h | 2.50 m | Extract air | .001 | Extract Air | Dra.no: 3 | 11 | 0.00 m/s | 3 | 0.0 Pa | Storey: 4 | CC= 2.50m FFB | Edge= 2.20m SSL | NN=9.30 m | CC= 0.80m FCL | .0000 | NNUK=9.00 m | CC= 2.50m SSL | Top= 0.00m FCL | Extract air
02.0000.01 | 02 Second floor | 293.266 | Y=13.03 | X=19.18 | 02 | 0.0 m\X\B3/h | 2.90 m | Extract air | .001 | Extract Air | Dra.no: 3 | 11 | 0.00 m/s | 0 | 0.0 Pa | Storey: 4 | CC= 2.77m FFB | Edge= 2.47m SSL | NN=9.70 m | CC= 0.53m FCL | .0000 | NNUK=9.40 m | CC= 2.77m SSL | Top= 0.23m FCL | Extract air | Installation space | 02.04
02.0000.01 | 02 Second floor | 600 | Y=12.63 | X=19.18 | 02 | 0.0 m\X\B3/h | 1.90 m | Extract air | .001 | Extract Air | Dra.no: 3 | 11 | 0.00 m/s | 1 | 0.0 Pa | Storey: 4 | CC= 1.77m FFB | Edge= 1.47m SSL | NN=8.70 m | CC= 1.53m FCL | .0000 | NNUK=8.40 m | CC= 1.77m SSL | Top= 1.23m FCL | Extract air | Installation space | 02.04
02.0000.01 | 02 Second floor | 289.782 | Y=11.94 | X=19.18 | 02 | 0.0 m\X\B3/h | 1.50 m | Extract air | .001 | Extract Air | Dra.no: 3 | 11 | 0.00 m/s | 0 | 0.0 Pa | Storey: 4 | CC= 1.37m FFB | Edge= 1.07m SSL | NN=8.30 m | CC= 1.93m FCL | .0000 | NNUK=8.00 m | CC= 1.37m SSL | Top= 1.63m FCL | Extract air | Installation space | 02.04
02.0000.01 | 02 Second floor | 57.7682 | Y=12.00 | X=17.63 | 02 | 0.0 m\X\B3/h | 1.50 m | Extract air | .001 | Extract Air | Dra.no: 3 | 11 | 0.00 m/s | 0 | 0.0 Pa | Storey: 4 | CC= 1.37m FFB | Edge= 1.07m SSL | NN=8.30 m | CC= 1.93m FCL | .0000 | NNUK=8.00 m | CC= 1.37m SSL | Top= 1.63m FCL | Extract air | Installation space | 02.04
02.0000.01 | 02 Second floor | 756.588 | Y=11.54 | X=18.03 | 02 | 0.0 m\X\B3/h | 1.50 m | Extract air | .001 | Extract Air | Dra.no: 3 | 11 | 0.00 m/s | 1 | 0.0 Pa | Storey: 4 | CC= 1.37m FFB | Edge= 1.07m SSL | NN=8.30 m | CC= 1.93m FCL | .0000 | NNUK=8.00 m | CC= 1.37m SSL | Top= 1.63m FCL | Extract air | Installation space | 02.04
03.0000.01 | 02 Second floor | 2350 | Y=17.16 | X=17.63 | 03 | 0.0 m\X\B3/h | 0.90 m | 3-PI Piping | .001 | Outdoor Air | Dra.no: 3 | 13 | 0.00 m/s | 2 | 0.0 Pa | Storey: 4 | CC= 0.77m FFB | Edge= 0.47m SSL | NN=7.70 m | CC= 2.53m FCL | .0000 | NNUK=7.40 m | CC= 0.77m SSL | Top= 2.23m FCL | Outdoor air | Installation space | 02.04
03.0000.01 | 02 Second floor | 760.728 | Y=16.00 | X=17.63 | 03 | 0.0 m\X\B3/h | 0.50 m | 3-PI Piping | .001 | Outdoor Air | Dra.no: 3 | 13 | 0.00 m/s | 1 | 0.0 Pa | Storey: 4 | CC= 0.37m FFB | Edge= 0.07m SSL | NN=7.30 m | CC= 2.93m FCL | .0000 | NNUK=7.00 m | CC= 0.37m SSL | Top= 2.63m FCL | Outdoor air | Installation space | 02.04
Duct | 01 First floor | 3750 | Y=13.73 | X=30.60 | 00 | 0.0 m\X\B3/h | 3.45 m |  | .007 | Extract Air | Dra.no: 2 | 11 | 0.00 m/s | 4 | 0.0 Pa | Storey: 3 | CC= 3.45m FFB | Edge= 3.15m SSL | NN=6.75 m | CC= -0.15m FCL | .0000 | NNUK=6.45 m | CC= 3.45m SSL | Top= 0.00m FCL

# IfcFlowSegment: HT12/0319 (36)
Type - Description: HT sewer pipe DN 50; ApplicableOccurrence: Drainage; PredefinedType: RIGIDSEGMENT
Type - Pset_ManufacturerTypeInformation - ArticleNumber: HT12/0319; ModelReference: HT sewer pipe DN 50; Manufacturer: DDS
Type - Pset_PipeSegmentTypeCommon - NominalDiameter: 50; InnerDiameter: 46.4; OuterDiameter: 50
Material: ML-HT sewer pipe DN 50
Pset_DDS - Outside dimension: 50.000001; Pressure drop: 0 Pa; Drain slope: 1:100; Medium: Sewer; Manufacturer: DDS; Ins thickness: ins= 0.000000 mm; Drain slope (%): 1.0 %; Drain slope (\X\B0): 0.6\X\B0; Layer number: 178; Main string number: 00; Width: 50; Dimension DN: 50; Project name: OpenBIM; Product Number: HT12/0319; Insulation WSVO: 0; Insulation k-value: 0; Drain Qww: Qww=0.00 l/s; Flow (l/h): 0.000000 l/h; Part number: .000; Sub string number: .0000; Temperature: 0.00 \X\B0C; Drain DU: DU=0.00 l/s; Product: HT sewer pipe DN 50; Building Part: Building: 0; Peak flow (l/s): 0.00 l/s; Flow (l/s): 0.00 l/s; Abs. pressure: 0.0 Pa; Velocity: 0.00 m/s; Flowsegment thickness: x1.8
AC_Pset_RenovationAndPhasing - Renovation Status: Existing
Name | In | Mtg. Below Ceiling ref Top | Above Sea Level ref. Center | Y | Mtg. Above Slab ref Bottom | Mounting Height | Model Number | Above Sea Level ref. Bottom | Pset_DDS, Length | Floor number | Mtg. above Finished Floor ref Center | X | Mtg. Below Ceiling ref Center | Mtg. Above Slab ref Center | Pset_FlowSegmentPipeSegment, Length (mm)
Pipe | 00 Ground floor | Top= 2.72m FCL | NN=0.35 m | Y=15.17 | Edge= 0.52m SSL | 0.55 m | Dra.no: 1 | NNUK=0.32 m | 0 | Storey: 2 | CC= 0.55m FFB | X=23.21 | CC= 2.75m FCL | CC= 0.55m SSL | 10.2818 | Pset_DDS - Room tekst: wc; Room number: 00.09
Pipe | 00 Ground floor | Top= 3.20m FCL | NN=-0.12 m | Y=15.20 | Edge= 0.05m SSL | 0.08 m | Dra.no: 1 | NNUK=-0.15 m | 0 | Storey: 2 | CC= 0.08m FFB | X=23.21 | CC= 3.22m FCL | CC= 0.08m SSL | 444.535 | Pset_DDS - Room tekst: Hallway; Room number: 00.02
Pipe | 00 Ground floor | Top= 3.28m FCL | NN=-0.27 m | Y=15.20 | Edge= -0.16m SSL | -0.07 m | Dra.no: 1 | NNUK=-0.36 m | 0 | Storey: 2 | CC= -0.07m FFB | X=23.08 | CC= 3.37m FCL | CC= -0.07m SSL | 173.731 | Pset_DDS - Room tekst: Hallway; Room number: 00.02
Pipe | 00 Ground floor | Top= 3.36m FCL | NN=-0.29 m | Y=15.20 | Edge= -0.11m SSL | -0.09 m | Dra.no: 1 | NNUK=-0.31 m | 1 | Storey: 2 | CC= -0.09m FFB | X=22.28 | CC= 3.39m FCL | CC= -0.09m SSL | 775.861 | Pset_DDS - Room tekst: Hallway; Room number: 00.02
Pipe | 00 Ground floor | Top= -0.00m FCL | NN=-0.29 m | Y=15.06 | Edge= -0.11m SSL | -0.09 m | Dra.no: 1 | NNUK=-0.31 m | 0 | Storey: 2 | CC= -0.09m FFB | X=22.25 | CC= 3.59m FCL | CC= -0.09m SSL | 108.929
Pipe | 00 Ground floor | Top= 2.72m FCL | NN=0.35 m | Y=12.01 | Edge= 0.52m SSL | 0.55 m | Dra.no: 1 | NNUK=0.32 m | 0 | Storey: 2 | CC= 0.55m FFB | X=23.21 | CC= 2.75m FCL | CC= 0.55m SSL | 20.3017 | Pset_DDS - Room tekst: wc; Room number: 00.10
Pipe | 00 Ground floor | Top= 3.57m FCL | NN=-0.30 m | Y=11.98 | Edge= -0.12m SSL | -0.10 m | Dra.no: 1 | NNUK=-0.32 m | 1 | Storey: 2 | CC= -0.10m FFB | X=23.21 | CC= 3.60m FCL | CC= -0.10m SSL | 618.465 | Pset_DDS - Room tekst: Entrance; Room number: 00.01
Pipe | 00 Ground floor | Top= 3.61m FCL | NN=-0.33 m | Y=11.33 | Edge= -0.16m SSL | -0.13 m | Dra.no: 1 | NNUK=-0.36 m | 1 | Storey: 2 | CC= -0.13m FFB | X=23.21 | CC= 3.63m FCL | CC= -0.13m SSL | 621.749 | Pset_DDS - Room tekst: Entrance; Room number: 00.01
Pipe | 00 Ground floor | Top= 3.61m FCL | NN=-0.34 m | Y=11.28 | Edge= -0.16m SSL | -0.14 m | Dra.no: 1 | NNUK=-0.36 m | 0 | Storey: 2 | CC= -0.14m FFB | X=23.24 | CC= 3.64m FCL | CC= -0.14m SSL | 39.3098 | Pset_DDS - Room tekst: Entrance; Room number: 00.01
Pipe | 00 Ground floor | Top= -0.00m FCL | NN=0.35 m | Y=12.56 | Edge= 0.52m SSL | 0.55 m | Dra.no: 1 | NNUK=0.32 m | 0 | Storey: 2 | CC= 0.55m FFB | X=22.22 | CC= 2.95m FCL | CC= 0.55m SSL | 98.6176
Pipe | 00 Ground floor | Top= 0.00m FCL | NN=-0.19 m | Y=12.56 | Edge= -0.02m SSL | 0.01 m | Dra.no: 1 | NNUK=-0.22 m | 1 | Storey: 2 | CC= 0.01m FFB | X=22.25 | CC= 3.49m FCL | CC= 0.01m SSL | 510.701
Pipe | 00 Ground floor | Top= -0.06m FCL | NN=-0.24 m | Y=12.52 | Edge= -0.13m SSL | -0.04 m | Dra.no: 1 | NNUK=-0.33 m | 0 | Storey: 2 | CC= -0.04m FFB | X=22.25 | CC= 3.54m FCL | CC= -0.04m SSL | 39.3098
Pipe | 00 Ground floor | Top= -0.00m FCL | NN=0.35 m | Y=13.60 | Edge= 0.52m SSL | 0.55 m | Dra.no: 1 | NNUK=0.32 m | 0 | Storey: 2 | CC= 0.55m FFB | X=22.22 | CC= 2.95m FCL | CC= 0.55m SSL | 98.6176
Pipe | 00 Ground floor | Top= 0.00m FCL | NN=-0.18 m | Y=13.60 | Edge= -0.01m SSL | 0.02 m | Dra.no: 1 | NNUK=-0.21 m | 1 | Storey: 2 | CC= 0.02m FFB | X=22.25 | CC= 3.48m FCL | CC= 0.02m SSL | 500.272
Pipe | 00 Ground floor | Top= -0.06m FCL | NN=-0.23 m | Y=13.56 | Edge= -0.12m SSL | -0.03 m | Dra.no: 1 | NNUK=-0.32 m | 0 | Storey: 2 | CC= -0.03m FFB | X=22.25 | CC= 3.53m FCL | CC= -0.03m SSL | 39.3098
Pipe | 00 Ground floor | Top= -0.00m FCL | NN=0.35 m | Y=14.64 | Edge= 0.52m SSL | 0.55 m | Dra.no: 1 | NNUK=0.32 m | 0 | Storey: 2 | CC= 0.55m FFB | X=22.22 | CC= 2.95m FCL | CC= 0.55m SSL | 98.6176
Pipe | 00 Ground floor | Top= 0.00m FCL | NN=-0.14 m | Y=14.64 | Edge= 0.03m SSL | 0.06 m | Dra.no: 1 | NNUK=-0.17 m | 0 | Storey: 2 | CC= 0.06m FFB | X=22.25 | CC= 3.44m FCL | CC= 0.06m SSL | 459.843
Pipe | 00 Ground floor | Top= -0.06m FCL | NN=-0.22 m | Y=14.58 | Edge= -0.11m SSL | -0.02 m | Dra.no: 1 | NNUK=-0.31 m | 0 | Storey: 2 | CC= -0.02m FFB | X=22.25 | CC= 3.52m FCL | CC= -0.02m SSL | 81.7341
Pipe | 01 First floor | Top= 0.00m FCL | NN=3.31 m | Y=12.56 | Edge= -0.02m SSL | 0.01 m | Dra.no: 2 | NNUK=3.28 m | 1 | Storey: 3 | CC= 0.01m FFB | X=22.25 | CC= 3.29m FCL | CC= 0.01m SSL | 510.701
Pipe | 01 First floor | Top= -0.06m FCL | NN=3.26 m | Y=12.52 | Edge= -0.13m SSL | -0.04 m | Dra.no: 2 | NNUK=3.17 m | 0 | Storey: 3 | CC= -0.04m FFB | X=22.25 | CC= 3.34m FCL | CC= -0.04m SSL | 39.3098
Pipe | 01 First floor | Top= -0.00m FCL | NN=3.85 m | Y=13.60 | Edge= 0.52m SSL | 0.55 m | Dra.no: 2 | NNUK=3.82 m | 0 | Storey: 3 | CC= 0.55m FFB | X=22.22 | CC= 2.75m FCL | CC= 0.55m SSL | 98.6176
Pipe | 01 First floor | Top= 0.00m FCL | NN=3.32 m | Y=13.60 | Edge= -0.01m SSL | 0.02 m | Dra.no: 2 | NNUK=3.29 m | 1 | Storey: 3 | CC= 0.02m FFB | X=22.25 | CC= 3.28m FCL | CC= 0.02m SSL | 500.272
