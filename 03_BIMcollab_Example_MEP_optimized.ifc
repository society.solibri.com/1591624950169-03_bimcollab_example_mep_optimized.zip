Properties of the parts of a building model (IFC2X3), part 4 of 14

# IfcFlowFitting: BE3000035090 (47)
Name | In | Rotation | Mounting Height | Mtg. Below Ceiling ref Center | Mtg. Above Slab ref Bottom | Mtg. above Finished Floor ref Center | Main string number | Mtg. Above Slab ref Center | Ins thickness | Model Number | Layer number | X | Above Sea Level ref. Center | Insulation WSVO | Floor number | Y | Part number | Above Sea Level ref. Bottom | Sub string number | Medium | Mtg. Below Ceiling ref Top | Insulation product text | Insulation product number | Room number | Room tekst
Bend | 02 Second floor | 90.000000 | 2.60 m | CC= 0.70m FCL | Edge= 2.58m SSL | CC= 2.60m FFB | 00 | CC= 2.60m SSL | ins= 30.000000 mm | Dra.no: 3 | 5 | X=29.38 | NN=9.40 m | 100 | Storey: 4 | Y=11.94 | .000 | NNUK=9.37 m | .0000 | Heat flow | Top= 0.00m FCL | Fibre plastic covered | MK032100
Bend | 02 Second floor | 0.000000 | 2.70 m | CC= 0.73m FCL | Edge= 2.55m SSL | CC= 2.57m FFB | 00 | CC= 2.57m SSL | ins= 30.000000 mm | Dra.no: 3 | 6 | X=8.12 | NN=9.50 m | 100 | Storey: 4 | Y=15.22 | .000 | NNUK=9.47 m | .0000 | Heat return | Top= 0.71m FCL | Fibre plastic covered | MK032100 | 02.04 | Installation space
Bend | 02 Second floor | 0.000000 | 2.70 m | CC= 0.73m FCL | Edge= 2.55m SSL | CC= 2.57m FFB | 00 | CC= 2.57m SSL | ins= 30.000000 mm | Dra.no: 3 | 6 | X=8.56 | NN=9.50 m | 100 | Storey: 4 | Y=15.22 | .000 | NNUK=9.47 m | .0000 | Heat return | Top= 0.71m FCL | Fibre plastic covered | MK032100 | 02.04 | Installation space
Bend | 02 Second floor | 180.000000 | 2.70 m | CC= 0.73m FCL | Edge= 2.55m SSL | CC= 2.57m FFB | 00 | CC= 2.57m SSL | ins= 30.000000 mm | Dra.no: 3 | 6 | X=8.56 | NN=9.50 m | 100 | Storey: 4 | Y=11.21 | .000 | NNUK=9.47 m | .0000 | Heat return | Top= 0.71m FCL | Fibre plastic covered | MK032100 | 02.04 | Installation space
Bend | 02 Second floor | 180.000000 | 0.20 m | CC= 3.23m FCL | Edge= 0.05m SSL | CC= 0.07m FFB | 00 | CC= 0.07m SSL | ins= 9.000000 mm | Dra.no: 3 | 5 | X=8.27 | NN=7.00 m | 0 | Storey: 4 | Y=12.19 | .000 | NNUK=6.97 m | .0000 | Heat flow | Top= 3.21m FCL | Pipe insulation | ZP150/935 | 02.04 | Installation space
Bend | 02 Second floor | 180.000000 | 2.70 m | CC= 0.73m FCL | Edge= 2.55m SSL | CC= 2.57m FFB | 00 | CC= 2.57m SSL | ins= 30.000000 mm | Dra.no: 3 | 6 | X=28.27 | NN=9.50 m | 100 | Storey: 4 | Y=11.21 | .000 | NNUK=9.47 m | .0000 | Heat return | Top= 0.71m FCL | Fibre plastic covered | MK032100 | 02.03 | Unnamed
Bend | 02 Second floor | 90.000000 | 0.20 m | CC= 3.23m FCL | Edge= 0.05m SSL | CC= 0.07m FFB | 00 | CC= 0.07m SSL | ins= 9.000000 mm | Dra.no: 3 | 5 | X=8.03 | NN=7.00 m | 0 | Storey: 4 | Y=12.19 | .000 | NNUK=6.97 m | .0000 | Heat flow | Top= 3.21m FCL | Pipe insulation | ZP150/935 | 02.04 | Installation space
Bend | 02 Second floor | 0.000000 | 2.70 m | CC= 0.73m FCL | Edge= 2.55m SSL | CC= 2.57m FFB | 00 | CC= 2.57m SSL | ins= 30.000000 mm | Dra.no: 3 | 6 | X=28.27 | NN=9.50 m | 100 | Storey: 4 | Y=11.83 | .000 | NNUK=9.47 m | .0000 | Heat return | Top= 0.71m FCL | Fibre plastic covered | MK032100 | 02.03 | Unnamed
Bend | 02 Second floor | 90.000000 | 2.70 m | CC= 0.60m FCL | Edge= 2.68m SSL | CC= 2.70m FFB | 00 | CC= 2.70m SSL | ins= 30.000000 mm | Dra.no: 3 | 6 | X=29.38 | NN=9.50 m | 100 | Storey: 4 | Y=11.83 | .000 | NNUK=9.47 m | .0000 | Heat return | Top= 0.00m FCL | Fibre plastic covered | MK032100
Bend | 02 Second floor | 0.000000 | 2.40 m | CC= 1.03m FCL | Edge= 2.25m SSL | CC= 2.27m FFB | 00 | CC= 2.27m SSL | ins= 30.000000 mm | Dra.no: 3 | 5 | X=8.81 | NN=9.20 m | 100 | Storey: 4 | Y=14.84 | .000 | NNUK=9.17 m | .0000 | Heat flow | Top= 1.01m FCL | Fibre plastic covered | MK032100 | 02.04 | Installation space
Bend | 02 Second floor | 180.000000 | 2.40 m | CC= 1.03m FCL | Edge= 2.25m SSL | CC= 2.27m FFB | 00 | CC= 2.27m SSL | ins= 30.000000 mm | Dra.no: 3 | 5 | X=8.81 | NN=9.20 m | 100 | Storey: 4 | Y=12.85 | .000 | NNUK=9.17 m | .0000 | Heat flow | Top= 1.01m FCL | Fibre plastic covered | MK032100 | 02.04 | Installation space
Bend | 02 Second floor | 90.000000 | 2.40 m | CC= 1.03m FCL | Edge= 2.25m SSL | CC= 2.27m FFB | 00 | CC= 2.27m SSL | ins= 30.000000 mm | Dra.no: 3 | 5 | X=16.29 | NN=9.20 m | 100 | Storey: 4 | Y=12.85 | .000 | NNUK=9.17 m | .0000 | Heat flow | Top= 1.01m FCL | Fibre plastic covered | MK032100 | 02.04 | Installation space
Bend | 02 Second floor | 270.000000 | 0.60 m | CC= 2.83m FCL | Edge= 0.45m SSL | CC= 0.47m FFB | 00 | CC= 0.47m SSL | ins= 30.000000 mm | Dra.no: 3 | 5 | X=16.29 | NN=7.40 m | 100 | Storey: 4 | Y=12.85 | .000 | NNUK=7.37 m | .0000 | Heat flow | Top= 2.81m FCL | Fibre plastic covered | MK032100 | 02.04 | Installation space
Bend | 02 Second floor | 0.000000 | 2.40 m | CC= 1.03m FCL | Edge= 2.25m SSL | CC= 2.27m FFB | 00 | CC= 2.27m SSL | ins= 30.000000 mm | Dra.no: 3 | 6 | X=8.12 | NN=9.20 m | 100 | Storey: 4 | Y=14.97 | .000 | NNUK=9.17 m | .0000 | Heat return | Top= 1.01m FCL | Fibre plastic covered | MK032100 | 02.04 | Installation space
Bend | 02 Second floor | 0.000000 | 2.40 m | CC= 1.03m FCL | Edge= 2.25m SSL | CC= 2.27m FFB | 00 | CC= 2.27m SSL | ins= 30.000000 mm | Dra.no: 3 | 6 | X=8.93 | NN=9.20 m | 100 | Storey: 4 | Y=14.97 | .000 | NNUK=9.17 m | .0000 | Heat return | Top= 1.01m FCL | Fibre plastic covered | MK032100 | 02.04 | Installation space
Bend | 02 Second floor | 180.000000 | 2.40 m | CC= 1.03m FCL | Edge= 2.25m SSL | CC= 2.27m FFB | 00 | CC= 2.27m SSL | ins= 30.000000 mm | Dra.no: 3 | 6 | X=8.93 | NN=9.20 m | 100 | Storey: 4 | Y=12.97 | .000 | NNUK=9.17 m | .0000 | Heat return | Top= 1.01m FCL | Fibre plastic covered | MK032100 | 02.04 | Installation space
Bend | 02 Second floor | 0.000000 | 0.10 m | CC= 3.33m FCL | Edge= -0.05m SSL | CC= -0.03m FFB | 00 | CC= -0.03m SSL | ins= 9.000000 mm | Dra.no: 3 | 6 | X=8.03 | NN=6.90 m | 0 | Storey: 4 | Y=12.31 | .000 | NNUK=6.87 m | .0000 | Heat return | Top= 3.31m FCL | Pipe insulation | ZP150/935 | 02.04 | Installation space
Bend | 02 Second floor | 0.000000 | 2.40 m | CC= 1.03m FCL | Edge= 2.25m SSL | CC= 2.27m FFB | 00 | CC= 2.27m SSL | ins= 30.000000 mm | Dra.no: 3 | 6 | X=16.39 | NN=9.20 m | 100 | Storey: 4 | Y=12.97 | .000 | NNUK=9.17 m | .0000 | Heat return | Top= 1.01m FCL | Fibre plastic covered | MK032100 | 02.04 | Installation space
Bend | 02 Second floor | 180.000000 | 2.40 m | CC= 1.03m FCL | Edge= 2.25m SSL | CC= 2.27m FFB | 00 | CC= 2.27m SSL | ins= 30.000000 mm | Dra.no: 3 | 6 | X=16.39 | NN=9.20 m | 100 | Storey: 4 | Y=12.85 | .000 | NNUK=9.17 m | .0000 | Heat return | Top= 1.01m FCL | Fibre plastic covered | MK032100 | 02.04 | Installation space
Bend | 02 Second floor | 90.000000 | 0.20 m | CC= 3.23m FCL | Edge= 0.05m SSL | CC= 0.07m FFB | 00 | CC= 0.07m SSL | ins= 9.000000 mm | Dra.no: 3 | 5 | X=8.03 | NN=7.00 m | 0 | Storey: 4 | Y=13.45 | .000 | NNUK=6.97 m | .0000 | Heat flow | Top= 3.21m FCL | Pipe insulation | ZP150/935 | 02.04 | Installation space
Bend | 02 Second floor | 90.000000 | 2.40 m | CC= 1.03m FCL | Edge= 2.25m SSL | CC= 2.27m FFB | 00 | CC= 2.27m SSL | ins= 30.000000 mm | Dra.no: 3 | 6 | X=16.51 | NN=9.20 m | 100 | Storey: 4 | Y=12.85 | .000 | NNUK=9.17 m | .0000 | Heat return | Top= 1.01m FCL | Fibre plastic covered | MK032100 | 02.04 | Installation space
Bend | 02 Second floor | 270.000000 | 1.20 m | CC= 2.23m FCL | Edge= 1.05m SSL | CC= 1.07m FFB | 00 | CC= 1.07m SSL | ins= 30.000000 mm | Dra.no: 3 | 6 | X=16.51 | NN=8.00 m | 100 | Storey: 4 | Y=12.85 | .000 | NNUK=7.97 m | .0000 | Heat return | Top= 2.21m FCL | Fibre plastic covered | MK032100 | 02.04 | Installation space
Bend | 02 Second floor | 90.000000 | 0.20 m | CC= 3.23m FCL | Edge= 0.05m SSL | CC= 0.07m FFB | 00 | CC= 0.07m SSL | ins= 9.000000 mm | Dra.no: 3 | 5 | X=8.03 | NN=7.00 m | 0 | Storey: 4 | Y=12.82 | .000 | NNUK=6.97 m | .0000 | Heat flow | Top= 3.21m FCL | Pipe insulation | ZP150/935 | 02.04 | Installation space
Bend | 02 Second floor | 0.000000 | 2.60 m | CC= 0.83m FCL | Edge= 2.45m SSL | CC= 2.47m FFB | 00 | CC= 2.47m SSL | ins= 30.000000 mm | Dra.no: 3 | 5 | X=8.27 | NN=9.40 m | 100 | Storey: 4 | Y=15.09 | .000 | NNUK=9.37 m | .0000 | Heat flow | Top= 0.81m FCL | Fibre plastic covered | MK032100 | 02.04 | Installation space
Bend | 02 Second floor | 0.000000 | 2.40 m | CC= 1.03m FCL | Edge= 2.25m SSL | CC= 2.27m FFB | 00 | CC= 2.27m SSL | ins= 30.000000 mm | Dra.no: 3 | 5 | X=8.27 | NN=9.20 m | 100 | Storey: 4 | Y=14.84 | .000 | NNUK=9.17 m | .0000 | Heat flow | Top= 1.01m FCL | Fibre plastic covered | MK032100 | 02.04 | Installation space
Bend | 02 Second floor | 0.000000 | 2.60 m | CC= 0.83m FCL | Edge= 2.45m SSL | CC= 2.47m FFB | 00 | CC= 2.47m SSL | ins= 30.000000 mm | Dra.no: 3 | 5 | X=8.45 | NN=9.40 m | 100 | Storey: 4 | Y=15.09 | .000 | NNUK=9.37 m | .0000 | Heat flow | Top= 0.81m FCL | Fibre plastic covered | MK032100 | 02.04 | Installation space
Bend | 02 Second floor | 180.000000 | 2.60 m | CC= 0.83m FCL | Edge= 2.45m SSL | CC= 2.47m FFB | 00 | CC= 2.47m SSL | ins= 30.000000 mm | Dra.no: 3 | 5 | X=8.45 | NN=9.40 m | 100 | Storey: 4 | Y=11.33 | .000 | NNUK=9.37 m | .0000 | Heat flow | Top= 0.81m FCL | Fibre plastic covered | MK032100 | 02.04 | Installation space

# IfcFlowFitting: BE3000054030 (2)
In: 02 Second floor
Type - Description: Cu fitting bend 30\X\B0 54x2 mm; ApplicableOccurrence: Basic; PredefinedType: BEND
Type - Pset_ManufacturerTypeInformation - ArticleNumber: BE3000054030; ModelReference: Cu fitting bend 30\X\B0 54x2 mm; Manufacturer: DDS
Type - Pset_PipeFittingTypeCommon - SubType: Bend 30 degree; NominalDiameter: 50; InnerDiameter: 50; OuterDiameter: 54
Material: IFC Building Material
Pset_DDS - Mtg. Above Slab ref Bottom: Edge= -0.06m SSL; Mounting Height: 0.10 m; Above Sea Level ref. Center: NN=6.90 m; Dimension DN: 50 mm; Mtg. Below Ceiling ref Center: CC= 3.33m FCL; Product: Cu fitting bend 30\X\B0 54x2 mm; Mtg. above Finished Floor ref Center: CC= -0.03m FFB; Insulation product text: Pipe insulation; Manufacturer: DDS; Insulation product number: ZP150/949; Ins thickness: ins= 9.000000 mm; Mtg. Above Slab ref Center: CC= -0.03m SSL; Room tekst: Installation space; Mtg. Below Ceiling ref Top: Top= 3.31m FCL; Model Number: Dra.no: 3; Layer number: 6; Width: 50; Main string number: 00; Project name: OpenBIM; Above Sea Level ref. Bottom: NNUK=6.85 m; Height: 0; Insulation k-value: 0; Pressure drop: 0; Insulation WSVO: 0; Flow (m\X\B3/h): 0.0 m\X\B3/h; Floor number: Storey: 4; Flow (l/h): 0.000000 l/h; Length: 30.0 m; Part number: .000; Sub string number: .0000; Pipe thickness:: x2.0; Product Number: BE3000054030; Outside dimension: 54.000000; Room number: 02.04; Medium: Heat return; Building Part: Building: 0; Flow (l/s): 0.00 l/s; Abs. pressure: 0.0 Pa; Velocity: 0.00 m/s
AC_Pset_RenovationAndPhasing - Renovation Status: Existing
Name | Rotation | X | Y
Bend | 180.000015 | X=8.12 | Y=14.26
Bend | 0.000000 | X=8.03 | Y=14.11

# IfcFlowFitting: BE3000054090 (6)
In: 02 Second floor
Type - Description: Cu fitting bend 90\X\B0 54x2 mm; ApplicableOccurrence: Basic; PredefinedType: BEND
Type - Pset_ManufacturerTypeInformation - ArticleNumber: BE3000054090; ModelReference: Cu fitting bend 90\X\B0 54x2 mm; Manufacturer: DDS
Type - Pset_PipeFittingTypeCommon - SubType: Bend 90 degree; NominalDiameter: 50; InnerDiameter: 50; OuterDiameter: 54
Material: IFC Building Material
Pset_DDS - Dimension DN: 50 mm; Insulation product text: Pipe insulation; Product: Cu fitting bend 90\X\B0 54x2 mm; Manufacturer: DDS; Insulation product number: ZP150/949; Ins thickness: ins= 9.000000 mm; Room tekst: Installation space; Model Number: Dra.no: 3; Width: 50; Main string number: 00; Project name: OpenBIM; Height: 0; Insulation k-value: 0; Pressure drop: 0; Insulation WSVO: 0; Flow (m\X\B3/h): 0.0 m\X\B3/h; Floor number: Storey: 4; Flow (l/h): 0.000000 l/h; Length: 90.0 m; Part number: .000; Sub string number: .0000; Pipe thickness:: x2.0; Product Number: BE3000054090; Outside dimension: 54.000000; Room number: 02.04; Building Part: Building: 0; Flow (l/s): 0.00 l/s; Abs. pressure: 0.0 Pa; Velocity: 0.00 m/s
AC_Pset_RenovationAndPhasing - Renovation Status: Existing
Name | Mounting Height | Mtg. Below Ceiling ref Center | Y | Mtg. Above Slab ref Bottom | Medium | Above Sea Level ref. Bottom | Mtg. above Finished Floor ref Center | Rotation | X | Layer number | Above Sea Level ref. Center | Mtg. Above Slab ref Center | Mtg. Below Ceiling ref Top
Bend | 2.40 m | CC= 1.03m FCL | Y=14.34 | Edge= 2.24m SSL | Heat flow | NNUK=9.15 m | CC= 2.27m FFB | 89.999970 | X=8.27 | 5 | NN=9.20 m | CC= 2.27m SSL | Top= 1.01m FCL
Bend | 0.20 m | CC= 3.23m FCL | Y=14.34 | Edge= 0.04m SSL | Heat flow | NNUK=6.95 m | CC= 0.07m FFB | 270.000000 | X=8.27 | 5 | NN=7.00 m | CC= 0.07m SSL | Top= 3.21m FCL
Bend | 2.40 m | CC= 1.03m FCL | Y=14.72 | Edge= 2.24m SSL | Heat return | NNUK=9.15 m | CC= 2.27m FFB | 90.000000 | X=8.12 | 6 | NN=9.20 m | CC= 2.27m SSL | Top= 1.01m FCL
Bend | 0.10 m | CC= 3.33m FCL | Y=14.34 | Edge= -0.05m SSL | Heat return | NNUK=6.85 m | CC= -0.03m FFB | 270.000000 | X=8.12 | 6 | NN=6.90 m | CC= -0.03m SSL | Top= 3.31m FCL
Bend | 2.40 m | CC= 1.03m FCL | Y=14.34 | Edge= 2.24m SSL | Heat return | NNUK=9.15 m | CC= 2.27m FFB | 90.000012 | X=8.12 | 6 | NN=9.20 m | CC= 2.27m SSL | Top= 1.01m FCL
Bend | 2.40 m | CC= 1.03m FCL | Y=14.59 | Edge= 2.24m SSL | Heat flow | NNUK=9.15 m | CC= 2.27m FFB | 90.000000 | X=8.27 | 5 | NN=9.20 m | CC= 2.27m SSL | Top= 1.01m FCL

# IfcFlowFitting: BE3000108090 (2)
In: 02 Second floor
Type - Description: Cu fitting bend 90\X\B0 108x2,5 mm; ApplicableOccurrence: Basic; PredefinedType: BEND
Type - Pset_ManufacturerTypeInformation - ArticleNumber: BE3000108090; ModelReference: Cu fitting bend 90\X\B0 108x2,5 mm; Manufacturer: DDS
Type - Pset_PipeFittingTypeCommon - SubType: Bend 90 degree; NominalDiameter: 100; InnerDiameter: 103; OuterDiameter: 108
Material: IFC Building Material
Pset_DDS - Product: Cu fitting bend 90\X\B0 108x2,5 mm; Mounting Height: 1.80 m; Mtg. Below Ceiling ref Center: CC= 1.63m FCL; X: X=8.06; Mtg. Above Slab ref Bottom: Edge= 1.62m SSL; Manufacturer: DDS; Dimension DN: 100 mm; Ins thickness: ins= 9.000000 mm; Above Sea Level ref. Bottom: NNUK=8.50 m; Room tekst: Installation space; Mtg. above Finished Floor ref Center: CC= 1.67m FFB; Medium: Smoke Exhaust; Insulation product text: Pipe insulation; Model Number: Dra.no: 3; Layer number: 16; Product Number: BE3000108090; Main string number: 00; Width: 100; Project name: OpenBIM; Height: 0; Insulation k-value: 0; Pressure drop: 0; Insulation WSVO: 0; Mtg. Above Slab ref Center: CC= 1.67m SSL; Flow (m\X\B3/h): 0.0 m\X\B3/h; Floor number: Storey: 4; Mtg. Below Ceiling ref Top: Top= 1.58m FCL; Outside dimension: 108.000000; Flow (l/h): 0.000000 l/h; Length: 90.0 m; Part number: .000; Sub string number: .0000; Room number: 02.04; Insulation product number: ZP150/952; Above Sea Level ref. Center: NN=8.60 m; Building Part: Building: 0; Flow (l/s): 0.00 l/s; Abs. pressure: 0.0 Pa; Velocity: 0.00 m/s; Pipe thickness:: x2.5
AC_Pset_RenovationAndPhasing - Renovation Status: Existing
Name | Rotation | Y
Bend | 270.000000 | Y=14.12
Bend | 180.000000 | Y=12.25

# IfcFlowFitting: BE5100050045 (12)
Type - Description: HT bend 45\X\B0 DN 50; ApplicableOccurrence: Basic; PredefinedType: BEND
Type - Pset_ManufacturerTypeInformation - ArticleNumber: BE5100050045; ModelReference: HT bend 45\X\B0 DN 50; Manufacturer: DDS
Type - Pset_PipeFittingTypeCommon - SubType: Bend 45 degree; NominalDiameter: 50; InnerDiameter: 46.4; OuterDiameter: 50
Material: IFC Building Material
Pset_DDS - Outside dimension: 50.000001; Dimension DN: 50 mm; Length: 45.0 m; Product Number: BE5100050045; Medium: Sewer; Manufacturer: DDS; Ins thickness: ins= 0.000000 mm; Product: HT bend 45\X\B0 DN 50; Layer number: 178; Width: 50; Main string number: 00; Project name: OpenBIM; Height: 0; Insulation k-value: 0; Pressure drop: 0; Insulation WSVO: 0; Flow (m\X\B3/h): 0.0 m\X\B3/h; Flow (l/h): 0.000000 l/h; Part number: .000; Sub string number: .0000; Building Part: Building: 0; Flow (l/s): 0.00 l/s; Abs. pressure: 0.0 Pa; Velocity: 0.00 m/s; Pipe thickness:: x1.8
AC_Pset_RenovationAndPhasing - Renovation Status: Existing
Name | In | Mtg. Above Slab ref Bottom | Rotation | Mounting Height | X | Y | Above Sea Level ref. Bottom | Model Number | Floor number | Above Sea Level ref. Center | Mtg. above Finished Floor ref Center | Mtg. Below Ceiling ref Center | Mtg. Above Slab ref Center | Mtg. Below Ceiling ref Top
Bend | 00 Ground floor | Edge= 0.02m SSL | 270.000000 | 0.05 m | X=22.25 | Y=14.64 | NNUK=-0.20 m | Dra.no: 1 | Storey: 2 | NN=-0.15 m | CC= 0.05m FFB | CC= 3.45m FCL | CC= 0.05m SSL | Top= 0.00m FCL
Bend | 00 Ground floor | Edge= -0.02m SSL | 270.000000 | 0.01 m | X=22.25 | Y=13.60 | NNUK=-0.24 m | Dra.no: 1 | Storey: 2 | NN=-0.19 m | CC= 0.01m FFB | CC= 3.49m FCL | CC= 0.01m SSL | Top= 0.00m FCL
Bend | 00 Ground floor | Edge= -0.03m SSL | 270.000000 | -0.00 m | X=22.25 | Y=12.56 | NNUK=-0.25 m | Dra.no: 1 | Storey: 2 | NN=-0.20 m | CC= -0.00m FFB | CC= 3.50m FCL | CC= -0.00m SSL | Top= 0.00m FCL
Bend | 00 Ground floor | Edge= -0.16m SSL | 359.762433 | -0.14 m | X=23.21 | Y=11.32 | NNUK=-0.39 m | Dra.no: 1 | Storey: 2 | NN=-0.34 m | CC= -0.14m FFB | CC= 3.64m FCL | CC= -0.14m SSL | Top= 3.61m FCL | Pset_DDS - Room tekst: Entrance; Room number: 00.01
Bend | 00 Ground floor | Edge= -0.10m SSL | 270.000000 | -0.08 m | X=23.07 | Y=15.20 | NNUK=-0.33 m | Dra.no: 1 | Storey: 2 | NN=-0.28 m | CC= -0.08m FFB | CC= 3.38m FCL | CC= -0.08m SSL | Top= 3.35m FCL | Pset_DDS - Room tekst: Hallway; Room number: 00.02
Bend | 00 Ground floor | Edge= 0.04m SSL | 270.000000 | 0.06 m | X=23.21 | Y=15.20 | NNUK=-0.19 m | Dra.no: 1 | Storey: 2 | NN=-0.14 m | CC= 0.06m FFB | CC= 3.24m FCL | CC= 0.06m SSL | Top= 3.21m FCL | Pset_DDS - Room tekst: Hallway; Room number: 00.02
Bend | 01 First floor | Edge= 0.02m SSL | 270.000000 | 0.05 m | X=22.25 | Y=14.64 | NNUK=3.30 m | Dra.no: 2 | Storey: 3 | NN=3.35 m | CC= 0.05m FFB | CC= 3.25m FCL | CC= 0.05m SSL | Top= 0.00m FCL
Bend | 01 First floor | Edge= -0.29m SSL | 359.762433 | -0.14 m | X=23.21 | Y=11.32 | NNUK=3.11 m | Dra.no: 2 | Storey: 3 | NN=3.16 m | CC= -0.27m FFB | CC= 3.57m FCL | CC= -0.27m SSL | Top= 3.54m FCL | Pset_DDS - Room tekst: Restaurant; Room number: 01.03
Bend | 01 First floor | Edge= -0.03m SSL | 270.000000 | -0.00 m | X=22.25 | Y=12.56 | NNUK=3.25 m | Dra.no: 2 | Storey: 3 | NN=3.30 m | CC= -0.00m FFB | CC= 3.30m FCL | CC= -0.00m SSL | Top= 0.00m FCL
Bend | 01 First floor | Edge= -0.23m SSL | 270.000000 | -0.08 m | X=23.07 | Y=15.20 | NNUK=3.17 m | Dra.no: 2 | Storey: 3 | NN=3.22 m | CC= -0.21m FFB | CC= 3.51m FCL | CC= -0.21m SSL | Top= 3.48m FCL | Pset_DDS - Room tekst: Hallway; Room number: 01.01
Bend | 01 First floor | Edge= -0.09m SSL | 270.000000 | 0.06 m | X=23.21 | Y=15.20 | NNUK=3.31 m | Dra.no: 2 | Storey: 3 | NN=3.36 m | CC= -0.07m FFB | CC= 3.37m FCL | CC= -0.07m SSL | Top= 3.34m FCL | Pset_DDS - Room tekst: Hallway; Room number: 01.01
Bend | 01 First floor | Edge= -0.02m SSL | 270.000000 | 0.01 m | X=22.25 | Y=13.60 | NNUK=3.26 m | Dra.no: 2 | Storey: 3 | NN=3.31 m | CC= 0.01m FFB | CC= 3.29m FCL | CC= 0.01m SSL | Top= 0.00m FCL

# IfcFlowFitting: BE5100050090 (14)
Type - Description: HT bend 90\X\B0 DN 50; ApplicableOccurrence: Basic; PredefinedType: BEND
Type - Pset_ManufacturerTypeInformation - ArticleNumber: BE5100050090; ModelReference: HT bend 90\X\B0 DN 50; Manufacturer: DDS
Type - Pset_PipeFittingTypeCommon - SubType: Bend 90 degree; NominalDiameter: 50; InnerDiameter: 46.4; OuterDiameter: 50
Material: IFC Building Material
Pset_DDS - Outside dimension: 50.000001; Dimension DN: 50 mm; Medium: Sewer; Product Number: BE5100050090; Manufacturer: DDS; Ins thickness: ins= 0.000000 mm; Product: HT bend 90\X\B0 DN 50; Layer number: 178; Width: 50; Main string number: 00; Project name: OpenBIM; Height: 0; Insulation k-value: 0; Pressure drop: 0; Insulation WSVO: 0; Flow (m\X\B3/h): 0.0 m\X\B3/h; Flow (l/h): 0.000000 l/h; Length: 90.0 m; Part number: .000; Sub string number: .0000; Building Part: Building: 0; Flow (l/s): 0.00 l/s; Abs. pressure: 0.0 Pa; Velocity: 0.00 m/s; Pipe thickness:: x1.8
AC_Pset_RenovationAndPhasing - Renovation Status: Existing
Name | In | Above Sea Level ref. Center | Rotation | Mtg. Above Slab ref Bottom | Mounting Height | X | Y | Model Number | Above Sea Level ref. Bottom | Floor number | Mtg. above Finished Floor ref Center | Mtg. Below Ceiling ref Center | Mtg. Above Slab ref Center | Mtg. Below Ceiling ref Top | Room tekst | Room number
Bend | 00 Ground floor | NN=0.35 m | 180.000000 | Edge= 0.52m SSL | 0.55 m | X=22.25 | Y=14.64 | Dra.no: 1 | NNUK=0.30 m | Storey: 2 | CC= 0.55m FFB | CC= 2.95m FCL | CC= 0.55m SSL | Top= 0.00m FCL
Bend | 00 Ground floor | NN=0.35 m | 180.000000 | Edge= 0.52m SSL | 0.55 m | X=22.25 | Y=13.60 | Dra.no: 1 | NNUK=0.30 m | Storey: 2 | CC= 0.55m FFB | CC= 2.95m FCL | CC= 0.55m SSL | Top= 0.00m FCL
Bend | 00 Ground floor | NN=0.35 m | 180.000000 | Edge= 0.52m SSL | 0.55 m | X=22.25 | Y=12.56 | Dra.no: 1 | NNUK=0.30 m | Storey: 2 | CC= 0.55m FFB | CC= 2.95m FCL | CC= 0.55m SSL | Top= 0.00m FCL
Bend | 00 Ground floor | NN=-0.33 m | 270.000000 | Edge= -0.15m SSL | -0.13 m | X=23.21 | Y=11.98 | Dra.no: 1 | NNUK=-0.38 m | Storey: 2 | CC= -0.13m FFB | CC= 3.63m FCL | CC= -0.13m SSL | Top= 3.60m FCL | Entrance | 00.01
Bend | 00 Ground floor | NN=0.35 m | 90.005780 | Edge= 0.52m SSL | 0.55 m | X=23.21 | Y=11.98 | Dra.no: 1 | NNUK=0.30 m | Storey: 2 | CC= 0.55m FFB | CC= 2.95m FCL | CC= 0.55m SSL | Top= 2.93m FCL | Entrance | 00.01
Bend | 00 Ground floor | NN=-0.29 m | 359.427338 | Edge= -0.11m SSL | -0.09 m | X=22.25 | Y=15.20 | Dra.no: 1 | NNUK=-0.34 m | Storey: 2 | CC= -0.09m FFB | CC= 3.39m FCL | CC= -0.09m SSL | Top= 3.36m FCL | Hallway | 00.02
Bend | 00 Ground floor | NN=0.35 m | 0.000000 | Edge= 0.52m SSL | 0.55 m | X=23.21 | Y=15.20 | Dra.no: 1 | NNUK=0.30 m | Storey: 2 | CC= 0.55m FFB | CC= 2.75m FCL | CC= 0.55m SSL | Top= 2.73m FCL | Hallway | 00.02
Bend | 01 First floor | NN=3.85 m | 180.000000 | Edge= 0.52m SSL | 0.55 m | X=22.25 | Y=14.64 | Dra.no: 2 | NNUK=3.80 m | Storey: 3 | CC= 0.55m FFB | CC= 2.75m FCL | CC= 0.55m SSL | Top= 0.00m FCL
Bend | 01 First floor | NN=3.85 m | 90.005780 | Edge= 0.39m SSL | 0.55 m | X=23.21 | Y=12.00 | Dra.no: 2 | NNUK=3.80 m | Storey: 3 | CC= 0.42m FFB | CC= 2.88m FCL | CC= 0.42m SSL | Top= 2.86m FCL | Restaurant | 01.03
Bend | 01 First floor | NN=3.17 m | 270.000000 | Edge= -0.28m SSL | -0.13 m | X=23.21 | Y=12.00 | Dra.no: 2 | NNUK=3.12 m | Storey: 3 | CC= -0.26m FFB | CC= 3.56m FCL | CC= -0.26m SSL | Top= 3.53m FCL | Restaurant | 01.03
Bend | 01 First floor | NN=3.85 m | 180.000000 | Edge= 0.52m SSL | 0.55 m | X=22.25 | Y=12.56 | Dra.no: 2 | NNUK=3.80 m | Storey: 3 | CC= 0.55m FFB | CC= 2.75m FCL | CC= 0.55m SSL | Top= 0.00m FCL
Bend | 01 First floor | NN=3.21 m | 359.427338 | Edge= -0.24m SSL | -0.09 m | X=22.25 | Y=15.20 | Dra.no: 2 | NNUK=3.16 m | Storey: 3 | CC= -0.22m FFB | CC= 3.52m FCL | CC= -0.22m SSL | Top= 3.49m FCL | Hallway | 01.01
Bend | 01 First floor | NN=3.85 m | 0.000000 | Edge= 0.39m SSL | 0.55 m | X=23.21 | Y=15.20 | Dra.no: 2 | NNUK=3.80 m | Storey: 3 | CC= 0.42m FFB | CC= 2.88m FCL | CC= 0.42m SSL | Top= 2.86m FCL | Hallway | 01.01
Bend | 01 First floor | NN=3.85 m | 180.000000 | Edge= 0.52m SSL | 0.55 m | X=22.25 | Y=13.60 | Dra.no: 2 | NNUK=3.80 m | Storey: 3 | CC= 0.55m FFB | CC= 2.75m FCL | CC= 0.55m SSL | Top= 0.00m FCL

# IfcFlowFitting: BE5100100045 (12)
Type - Description: HT bend 45\X\B0 DN 100; ApplicableOccurrence: Basic; PredefinedType: BEND
Type - Pset_ManufacturerTypeInformation - ArticleNumber: BE5100100045; ModelReference: HT bend 45\X\B0 DN 100; Manufacturer: DDS
Type - Pset_PipeFittingTypeCommon - SubType: Bend 45 degree; NominalDiameter: 100; InnerDiameter: 104.6; OuterDiameter: 110
Material: IFC Building Material
Pset_DDS - Length: 45.0 m; Medium: Sewer; Manufacturer: DDS; Rotation: 270.000000; Pipe thickness:: x2.7; Dimension DN: 100 mm; Ins thickness: ins= 0.000000 mm; Outside dimension: 109.999999; Layer number: 178; Main string number: 00; Width: 100; Project name: OpenBIM; Height: 0; Insulation k-value: 0; Pressure drop: 0; Insulation WSVO: 0; Flow (m\X\B3/h): 0.0 m\X\B3/h; Flow (l/h): 0.000000 l/h; Part number: .000; Sub string number: .0000; Product: HT bend 45\X\B0 DN 100; Building Part: Building: 0; Mtg. Below Ceiling ref Top: Top= 0.00m FCL; Product Number: BE5100100045; Flow (l/s): 0.00 l/s; Abs. pressure: 0.0 Pa; Velocity: 0.00 m/s
AC_Pset_RenovationAndPhasing - Renovation Status: Existing
Name | In | Mtg. Above Slab ref Bottom | Mounting Height | X | Y | Model Number | Floor number | Above Sea Level ref. Center | Mtg. above Finished Floor ref Center | Above Sea Level ref. Bottom | Mtg. Below Ceiling ref Center | Mtg. Above Slab ref Center
Bend | 00 Ground floor | Edge= -0.00m SSL | 0.05 m | X=22.25 | Y=13.05 | Dra.no: 1 | Storey: 2 | NN=-0.15 m | CC= 0.05m FFB | NNUK=-0.25 m | CC= 3.45m FCL | CC= 0.05m SSL
Bend | 00 Ground floor | Edge= -0.11m SSL | -0.06 m | X=18.69 | Y=14.53 | Dra.no: 1 | Storey: 2 | NN=-0.26 m | CC= -0.06m FFB | NNUK=-0.36 m | CC= 3.56m FCL | CC= -0.06m SSL
Bend | 00 Ground floor | Edge= 0.04m SSL | 0.09 m | X=18.69 | Y=14.67 | Dra.no: 1 | Storey: 2 | NN=-0.11 m | CC= 0.09m FFB | NNUK=-0.21 m | CC= 3.41m FCL | CC= 0.09m SSL
Bend | 00 Ground floor | Edge= 0.03m SSL | 0.08 m | X=18.69 | Y=13.61 | Dra.no: 1 | Storey: 2 | NN=-0.12 m | CC= 0.08m FFB | NNUK=-0.22 m | CC= 3.42m FCL | CC= 0.08m SSL
Bend | 00 Ground floor | Edge= 0.03m SSL | 0.08 m | X=18.69 | Y=12.53 | Dra.no: 1 | Storey: 2 | NN=-0.12 m | CC= 0.08m FFB | NNUK=-0.22 m | CC= 3.42m FCL | CC= 0.08m SSL
Bend | 00 Ground floor | Edge= 0.00m SSL | 0.05 m | X=22.25 | Y=14.17 | Dra.no: 1 | Storey: 2 | NN=-0.15 m | CC= 0.05m FFB | NNUK=-0.25 m | CC= 3.45m FCL | CC= 0.05m SSL
Bend | 01 First floor | Edge= 0.03m SSL | 0.08 m | X=18.69 | Y=13.61 | Dra.no: 2 | Storey: 3 | NN=3.38 m | CC= 0.08m FFB | NNUK=3.28 m | CC= 3.22m FCL | CC= 0.08m SSL
Bend | 01 First floor | Edge= 0.03m SSL | 0.08 m | X=18.69 | Y=12.53 | Dra.no: 2 | Storey: 3 | NN=3.38 m | CC= 0.08m FFB | NNUK=3.28 m | CC= 3.22m FCL | CC= 0.08m SSL
Bend | 01 First floor | Edge= 0.00m SSL | 0.05 m | X=22.25 | Y=14.17 | Dra.no: 2 | Storey: 3 | NN=3.35 m | CC= 0.05m FFB | NNUK=3.25 m | CC= 3.25m FCL | CC= 0.05m SSL
Bend | 01 First floor | Edge= -0.00m SSL | 0.05 m | X=22.25 | Y=13.05 | Dra.no: 2 | Storey: 3 | NN=3.35 m | CC= 0.05m FFB | NNUK=3.25 m | CC= 3.25m FCL | CC= 0.05m SSL
Bend | 01 First floor | Edge= -0.11m SSL | -0.06 m | X=18.69 | Y=14.53 | Dra.no: 2 | Storey: 3 | NN=3.24 m | CC= -0.06m FFB | NNUK=3.14 m | CC= 3.36m FCL | CC= -0.06m SSL
Bend | 01 First floor | Edge= 0.04m SSL | 0.09 m | X=18.69 | Y=14.67 | Dra.no: 2 | Storey: 3 | NN=3.39 m | CC= 0.09m FFB | NNUK=3.29 m | CC= 3.21m FCL | CC= 0.09m SSL

# IfcFlowFitting: BE5100100090 (12)
Type - Description: HT bend 90\X\B0 DN 100; ApplicableOccurrence: Basic; PredefinedType: BEND
Type - Pset_ManufacturerTypeInformation - ArticleNumber: BE5100100090; ModelReference: HT bend 90\X\B0 DN 100; Manufacturer: DDS
Type - Pset_PipeFittingTypeCommon - SubType: Bend 90 degree; NominalDiameter: 100; InnerDiameter: 104.6; OuterDiameter: 110
Material: IFC Building Material
Pset_DDS - Medium: Sewer; Manufacturer: DDS; Pipe thickness:: x2.7; Dimension DN: 100 mm; Ins thickness: ins= 0.000000 mm; Outside dimension: 109.999999; Product: HT bend 90\X\B0 DN 100; Layer number: 178; Main string number: 00; Width: 100; Project name: OpenBIM; Height: 0; Insulation k-value: 0; Pressure drop: 0; Insulation WSVO: 0; Flow (m\X\B3/h): 0.0 m\X\B3/h; Flow (l/h): 0.000000 l/h; Length: 90.0 m; Part number: .000; Sub string number: .0000; Product Number: BE5100100090; Building Part: Building: 0; Flow (l/s): 0.00 l/s; Abs. pressure: 0.0 Pa; Velocity: 0.00 m/s
AC_Pset_RenovationAndPhasing - Renovation Status: Existing
Name | In | Mtg. Above Slab ref Bottom | Mtg. Above Slab ref Center | X | Mounting Height | Y | Mtg. Below Ceiling ref Center | Model Number | Above Sea Level ref. Center | Floor number | Rotation | Mtg. above Finished Floor ref Center | Mtg. Below Ceiling ref Top | Above Sea Level ref. Bottom
Bend | 00 Ground floor | Edge= 0.18m SSL | CC= 0.23m SSL | X=22.25 | 0.23 m | Y=13.05 | CC= 3.27m FCL | Dra.no: 1 | NN=0.03 m | Storey: 2 | 0.000000 | CC= 0.23m FFB | Top= 0.00m FCL | NNUK=-0.07 m
Bend | 00 Ground floor | Edge= -0.14m SSL | CC= -0.09m SSL | X=18.69 | -0.09 m | Y=11.21 | CC= 3.59m FCL | Dra.no: 1 | NN=-0.29 m | Storey: 2 | 359.427338 | CC= -0.09m FFB | Top= 3.54m FCL | NNUK=-0.39 m | Pset_DDS - Room tekst: Entrance; Room number: 00.01
Bend | 00 Ground floor | Edge= 0.18m SSL | CC= 0.23m SSL | X=18.69 | 0.23 m | Y=14.67 | CC= 3.27m FCL | Dra.no: 1 | NN=0.03 m | Storey: 2 | 0.000000 | CC= 0.23m FFB | Top= 0.00m FCL | NNUK=-0.07 m
Bend | 00 Ground floor | Edge= 0.18m SSL | CC= 0.23m SSL | X=18.69 | 0.23 m | Y=13.61 | CC= 3.27m FCL | Dra.no: 1 | NN=0.03 m | Storey: 2 | 0.000000 | CC= 0.23m FFB | Top= 0.00m FCL | NNUK=-0.07 m
Bend | 00 Ground floor | Edge= 0.18m SSL | CC= 0.23m SSL | X=18.69 | 0.23 m | Y=12.53 | CC= 3.27m FCL | Dra.no: 1 | NN=0.03 m | Storey: 2 | 0.000000 | CC= 0.23m FFB | Top= 0.00m FCL | NNUK=-0.07 m
Bend | 00 Ground floor | Edge= 0.18m SSL | CC= 0.23m SSL | X=22.25 | 0.23 m | Y=14.17 | CC= 3.27m FCL | Dra.no: 1 | NN=0.03 m | Storey: 2 | 0.000000 | CC= 0.23m FFB | Top= 0.00m FCL | NNUK=-0.07 m
Bend | 01 First floor | Edge= 0.18m SSL | CC= 0.23m SSL | X=18.69 | 0.23 m | Y=14.67 | CC= 3.07m FCL | Dra.no: 2 | NN=3.53 m | Storey: 3 | 0.000000 | CC= 0.23m FFB | Top= 0.00m FCL | NNUK=3.43 m
Bend | 01 First floor | Edge= 0.18m SSL | CC= 0.23m SSL | X=18.69 | 0.23 m | Y=13.61 | CC= 3.07m FCL | Dra.no: 2 | NN=3.53 m | Storey: 3 | 0.000000 | CC= 0.23m FFB | Top= 0.00m FCL | NNUK=3.43 m
Bend | 01 First floor | Edge= 0.18m SSL | CC= 0.23m SSL | X=18.69 | 0.23 m | Y=12.53 | CC= 3.07m FCL | Dra.no: 2 | NN=3.53 m | Storey: 3 | 0.000000 | CC= 0.23m FFB | Top= 0.00m FCL | NNUK=3.43 m
Bend | 01 First floor | Edge= 0.18m SSL | CC= 0.23m SSL | X=22.25 | 0.23 m | Y=14.17 | CC= 3.07m FCL | Dra.no: 2 | NN=3.53 m | Storey: 3 | 0.000000 | CC= 0.23m FFB | Top= 0.00m FCL | NNUK=3.43 m
Bend | 01 First floor | Edge= 0.18m SSL | CC= 0.23m SSL | X=22.25 | 0.23 m | Y=13.05 | CC= 3.07m FCL | Dra.no: 2 | NN=3.53 m | Storey: 3 | 0.000000 | CC= 0.23m FFB | Top= 0.00m FCL | NNUK=3.43 m
Bend | 01 First floor | Edge= -0.27m SSL | CC= -0.22m SSL | X=18.69 | -0.09 m | Y=11.21 | CC= 3.52m FCL | Dra.no: 2 | NN=3.21 m | Storey: 3 | 359.427338 | CC= -0.22m FFB | Top= 3.47m FCL | NNUK=3.11 m | Pset_DDS - Room tekst: Restaurant; Room number: 01.03

# IfcFlowFitting: BE5100125045 (2)
In: -01 Foundation
Type - Description: HT bend 45\X\B0 DN 125; ApplicableOccurrence: Basic; PredefinedType: BEND
Type - Pset_ManufacturerTypeInformation - ArticleNumber: BE5100125045; ModelReference: HT bend 45\X\B0 DN 125; Manufacturer: DDS
Type - Pset_PipeFittingTypeCommon - SubType: Bend 45 degree; NominalDiameter: 125; InnerDiameter: 118.8; OuterDiameter: 125
Material: IFC Building Material
Pset_DDS - Length: 45.0 m; Product: HT bend 45\X\B0 DN 125; Product Number: BE5100125045; Outside dimension: 125.000003; Medium: Sewer; Manufacturer: DDS; X: X=29.65; Width: 125; Rotation: 270.000000; Ins thickness: ins= 0.000000 mm; Dimension DN: 125 mm; Model Number: Dra.no: 0; Pipe thickness:: x3.1; Layer number: 178; Main string number: 00; Project name: OpenBIM; Height: 0; Insulation k-value: 0; Pressure drop: 0; Insulation WSVO: 0; Flow (m\X\B3/h): 0.0 m\X\B3/h; Floor number: Storey: 1; Flow (l/h): 0.000000 l/h; Part number: .000; Sub string number: .0000; Building Part: Building: 0; Mtg. Below Ceiling ref Top: Top= 0.00m FCL; Flow (l/s): 0.00 l/s; Abs. pressure: 0.0 Pa; Velocity: 0.00 m/s
AC_Pset_RenovationAndPhasing - Renovation Status: Existing
Name | Mounting Height | Above Sea Level ref. Bottom | Mtg. Above Slab ref Bottom | Mtg. above Finished Floor ref Center | Mtg. Above Slab ref Center | Mtg. Below Ceiling ref Center | Above Sea Level ref. Center | Y
Bend | 0.10 m | NNUK=-1.02 m | Edge= 0.04m SSL | CC= 0.10m FFB | CC= 0.10m SSL | CC= 0.57m FCL | NN=-0.90 m | Y=11.10
Bend | 0.22 m | NNUK=-0.91 m | Edge= 0.15m SSL | CC= 0.22m FFB | CC= 0.22m SSL | CC= 0.45m FCL | NN=-0.78 m | Y=11.21

# IfcFlowFitting: BE8300125030 (7)
In: 00 Ground floor
Type - Description: Folded Spiral-Seam Circ Bend 30\X\B0 d 125; PredefinedType: BEND
Type - Pset_ManufacturerTypeInformation - ArticleNumber: BE8300125030; ModelReference: Folded Spiral-Seam Circ Bend 30\X\B0 d 125; Manufacturer: DDS
Type - Pset_DuctFittingTypeCommon - NominalDiameterOrWidth: 125; NominalHeight: 300
Material: IFC Building Material
Pset_DDS - Manufacturer: DDS; Width: 125; Ins thickness: ins= 0.000000 mm; Dimension DN: 125 mm; Model Number: Dra.no: 1; Length: 125.0 m; Product: Folded Spiral-Seam Circ Bend 30\X\B0 d 125; Project name: OpenBIM; Height: 0; Insulation k-value: 0; Pressure drop: 0; Insulation WSVO: 0; Floor number: Storey: 2; Pipe thickness:: x0.0; Outside dimension: 125.000000; Building Part: Building: 0; Product Number: BE8300125030
AC_Pset_RenovationAndPhasing - Renovation Status: Existing
Name | Mtg. Above Slab ref Center | Above Sea Level ref. Bottom | Mounting Height | X | Velocity | Above Sea Level ref. Center | Flow (l/h) | Flow (l/s) | Main string number | Rotation | Abs. pressure | Flow (m\X\B3/h) | System Name | Part number | Medium | Sub string number | Mtg. Below Ceiling ref Center | Room tekst | Mtg. Above Slab ref Bottom | Layer number | Room number | Mtg. Below Ceiling ref Top | Mtg. above Finished Floor ref Center | Y | Group
1.19.-2 | CC= 3.12m SSL | NNUK=2.68 m | 3.00 m | X=38.19 | 2.44 m/s | NN=2.80 m | 108000.000000 l/h | 30.00 l/s | 01 | 89.999998 | 223.6 Pa | 108.0 m\X\B3/h | Supply Air | .-002 | Supply Air | .0019 | CC= 0.18m FCL | Office | Edge= 3.06m SSL | 10 | 00.23 | Top= 0.12m FCL | CC= 3.12m FFB | Y=17.75 | Supply air
1.19.-4 | CC= 2.96m SSL | NNUK=2.52 m | 2.84 m | X=38.19 | 2.44 m/s | NN=2.64 m | 108000.000000 l/h | 30.00 l/s | 01 | 270.000000 | 221.6 Pa | 108.0 m\X\B3/h | Supply Air | .-004 | Supply Air | .0019 | CC= 0.34m FCL | Office | Edge= 2.90m SSL | 10 | 00.23 | Top= 0.27m FCL | CC= 2.96m FFB | Y=17.48 | Supply air
1.20.-2 | CC= 3.12m SSL | NNUK=2.68 m | 3.00 m | X=38.19 | 2.44 m/s | NN=2.80 m | 108000.000000 l/h | 30.00 l/s | 01 | 90.000000 | 223.6 Pa | 108.0 m\X\B3/h | Supply Air | .-002 | Supply Air | .0020 | CC= 0.18m FCL | Office | Edge= 3.06m SSL | 10 | 00.23 | Top= 0.12m FCL | CC= 3.12m FFB | Y=18.73 | Supply air
1.20.-4 | CC= 2.96m SSL | NNUK=2.52 m | 2.84 m | X=38.19 | 2.44 m/s | NN=2.64 m | 108000.000000 l/h | 30.00 l/s | 01 | 270.000000 | 221.6 Pa | 108.0 m\X\B3/h | Supply Air | .-004 | Supply Air | .0020 | CC= 0.34m FCL | Office | Edge= 2.90m SSL | 10 | 00.23 | Top= 0.27m FCL | CC= 2.96m FFB | Y=19.01 | Supply air
1.21.-2 | CC= 3.12m SSL | NNUK=2.68 m | 3.00 m | X=34.97 | 2.44 m/s | NN=2.80 m | 108000.000000 l/h | 30.00 l/s | 01 | 89.999994 | 224.6 Pa | 108.0 m\X\B3/h | Supply Air | .-002 | Supply Air | .0021 | CC= 0.18m FCL | Office | Edge= 3.06m SSL | 10 | 00.23 | Top= 0.12m FCL | CC= 3.12m FFB | Y=18.59 | Supply air
1.21.-4 | CC= 2.96m SSL | NNUK=2.52 m | 2.84 m | X=34.97 | 2.44 m/s | NN=2.64 m | 108000.000000 l/h | 30.00 l/s | 01 | 270.000000 | 222.6 Pa | 108.0 m\X\B3/h | Supply Air | .-004 | Supply Air | .0021 | CC= 0.34m FCL | Office | Edge= 2.90m SSL | 10 | 00.23 | Top= 0.27m FCL | CC= 2.96m FFB | Y=18.86 | Supply air
Bend | CC= 3.10m SSL | NNUK=2.77 m | 3.10 m | X=11.77 | 0.00 m/s | NN=2.90 m | 0.000000 l/h | 0.00 l/s | 00 | 0.000000 | 0.0 Pa | 0.0 m\X\B3/h |  | .000 | Extract Air | .0019 | CC= 0.20m FCL | Storage | Edge= 3.04m SSL | 11 | 00.13 | Top= 0.14m FCL | CC= 3.10m FFB | Y=13.19

# IfcFlowFitting: BE8300125045 (6)
In: 00 Ground floor
Type - Description: Folded Spiral-Seam Circ Bend 45\X\B0 d 125; PredefinedType: BEND
Type - Pset_ManufacturerTypeInformation - ArticleNumber: BE8300125045; ModelReference: Folded Spiral-Seam Circ Bend 45\X\B0 d 125; Manufacturer: DDS
Type - Pset_DuctFittingTypeCommon - NominalDiameterOrWidth: 125; NominalHeight: 200
Material: IFC Building Material; Group: Supply air
Pset_DDS - Product Number: BE8300125045; Velocity: 2.26 m/s; Main string number: 01; Manufacturer: DDS; Width: 125; Ins thickness: ins= 0.000000 mm; Flow (m\X\B3/h): 100.0 m\X\B3/h; System Name: Supply Air; Medium: Supply Air; Dimension DN: 125 mm; Product: Folded Spiral-Seam Circ Bend 45\X\B0 d 125; Model Number: Dra.no: 1; Layer number: 10; Length: 125.0 m; Project name: OpenBIM; Height: 0; Insulation k-value: 0; Pressure drop: 0; Insulation WSVO: 0; Floor number: Storey: 2; Pipe thickness:: x0.0; Outside dimension: 125.000000; Room tekst: Director office; Flow (l/s): 27.78 l/s; Flow (l/h): 100000.000000 l/h; Building Part: Building: 0
AC_Pset_RenovationAndPhasing - Renovation Status: Existing
Name | Mtg. Above Slab ref Center | Rotation | Above Sea Level ref. Bottom | Mounting Height | Above Sea Level ref. Center | Abs. pressure | Sub string number | X | Y | Mtg. Below Ceiling ref Center | Mtg. Above Slab ref Bottom | Room number | Part number | Mtg. Below Ceiling ref Top | Mtg. above Finished Floor ref Center
1.31.7 | CC= 3.12m SSL | 90.000000 | NNUK=2.68 m | 3.00 m | NN=2.80 m | 243.2 Pa | .0031 | X=38.75 | Y=9.00 | CC= 0.18m FCL | Edge= 3.06m SSL | 00.24 | .007 | Top= 0.12m FCL | CC= 3.12m FFB
1.31.9 | CC= 2.92m SSL | 270.000000 | NNUK=2.48 m | 2.80 m | NN=2.60 m | 241.6 Pa | .0031 | X=38.75 | Y=8.80 | CC= 0.38m FCL | Edge= 2.86m SSL | 00.24 | .009 | Top= 0.32m FCL | CC= 2.92m FFB
1.32.2 | CC= 2.87m SSL | 90.000003 | NNUK=2.68 m | 3.00 m | NN=2.80 m | 241.2 Pa | .0032 | X=35.00 | Y=9.08 | CC= 0.43m FCL | Edge= 2.81m SSL | 00.25 | .002 | Top= 0.37m FCL | CC= 2.87m FFB
1.32.4 | CC= 2.67m SSL | 270.000000 | NNUK=2.48 m | 2.80 m | NN=2.60 m | 239.5 Pa | .0032 | X=35.00 | Y=8.88 | CC= 0.63m FCL | Edge= 2.61m SSL | 00.25 | .004 | Top= 0.57m FCL | CC= 2.67m FFB
1.33.2 | CC= 2.87m SSL | 90.000003 | NNUK=2.68 m | 3.00 m | NN=2.80 m | 242.3 Pa | .0033 | X=33.12 | Y=9.08 | CC= 0.43m FCL | Edge= 2.81m SSL | 00.25 | .002 | Top= 0.37m FCL | CC= 2.87m FFB
1.33.4 | CC= 2.67m SSL | 270.000000 | NNUK=2.48 m | 2.80 m | NN=2.60 m | 240.6 Pa | .0033 | X=33.12 | Y=8.88 | CC= 0.63m FCL | Edge= 2.61m SSL | 00.25 | .004 | Top= 0.57m FCL | CC= 2.67m FFB

# IfcFlowFitting: BE8300125090 (12)
In: 00 Ground floor
Type - Description: Folded Spiral-Seam Circ Bend 90\X\B0 d 125; PredefinedType: BEND
Type - Pset_ManufacturerTypeInformation - ArticleNumber: BE8300125090; ModelReference: Folded Spiral-Seam Circ Bend 90\X\B0 d 125; Manufacturer: DDS
Type - Pset_DuctFittingTypeCommon - NominalDiameterOrWidth: 125; NominalHeight: 300
Material: IFC Building Material
Pset_DDS - Product: Folded Spiral-Seam Circ Bend 90\X\B0 d 125; Manufacturer: DDS; Width: 125; Ins thickness: ins= 0.000000 mm; Dimension DN: 125 mm; Model Number: Dra.no: 1; Length: 125.0 m; Project name: OpenBIM; Height: 0; Insulation k-value: 0; Pressure drop: 0; Insulation WSVO: 0; Floor number: Storey: 2; Pipe thickness:: x0.0; Outside dimension: 125.000000; Building Part: Building: 0; Product Number: BE8300125090
AC_Pset_RenovationAndPhasing - Renovation Status: Existing
Name | X | Velocity | Flow (l/h) | Flow (l/s) | Y | Main string number | Mounting Height | Flow (m\X\B3/h) | Abs. pressure | Mtg. Below Ceiling ref Top | Mtg. Above Slab ref Center | Mtg. above Finished Floor ref Center | Part number | Medium | Sub string number | Room tekst | Mtg. Below Ceiling ref Center | Layer number | Above Sea Level ref. Center | Room number | Above Sea Level ref. Bottom | Mtg. Above Slab ref Bottom | Rotation
1.19.-6 | X=38.19 | 2.44 m/s | 108000.000000 l/h | 30.00 l/s | Y=16.05 | 01 | 2.84 m | 108.0 m\X\B3/h | 218.7 Pa | Top= 0.27m FCL | CC= 2.96m SSL | CC= 2.96m FFB | .-006 | Supply Air | .0019 | Office | CC= 0.34m FCL | 10 | NN=2.64 m | 00.23 | NNUK=2.52 m | Edge= 2.90m SSL | 0.000000 | Pset_DDS - System Name: Supply Air; Group: Supply air
1.20.-6 | X=38.19 | 2.44 m/s | 108000.000000 l/h | 30.00 l/s | Y=19.80 | 01 | 2.84 m | 108.0 m\X\B3/h | 219.3 Pa | Top= 0.27m FCL | CC= 2.96m SSL | CC= 2.96m FFB | .-006 | Supply Air | .0020 | Office | CC= 0.34m FCL | 10 | NN=2.64 m | 00.23 | NNUK=2.52 m | Edge= 2.90m SSL | 180.000000 | Pset_DDS - System Name: Supply Air; Group: Supply air
1.21.-6 | X=34.97 | 2.44 m/s | 108000.000000 l/h | 30.00 l/s | Y=19.80 | 01 | 2.84 m | 108.0 m\X\B3/h | 220.1 Pa | Top= 0.27m FCL | CC= 2.96m SSL | CC= 2.96m FFB | .-006 | Supply Air | .0021 | Office | CC= 0.34m FCL | 10 | NN=2.64 m | 00.23 | NNUK=2.52 m | Edge= 2.90m SSL | 180.000000 | Pset_DDS - System Name: Supply Air; Group: Supply air
1.22.-6 | X=34.97 | 2.44 m/s | 108000.000000 l/h | 30.00 l/s | Y=16.05 | 01 | 2.84 m | 108.0 m\X\B3/h | 219.5 Pa | Top= 0.27m FCL | CC= 2.96m SSL | CC= 2.96m FFB | .-006 | Supply Air | .0022 | Office | CC= 0.34m FCL | 10 | NN=2.64 m | 00.23 | NNUK=2.52 m | Edge= 2.90m SSL | 0.000000 | Pset_DDS - System Name: Supply Air; Group: Supply air
1.31.5 | X=38.75 | 2.26 m/s | 100000.000000 l/h | 27.78 l/s | Y=9.28 | 01 | 3.00 m | 100.0 m\X\B3/h | 244.8 Pa | Top= 0.12m FCL | CC= 3.12m SSL | CC= 3.12m FFB | .005 | Supply Air | .0031 | Director office | CC= 0.18m FCL | 10 | NN=2.80 m | 00.24 | NNUK=2.68 m | Edge= 3.06m SSL | 0.000000 | Pset_DDS - System Name: Supply Air; Group: Supply air
Bend | X=19.56 | 0.00 m/s | 0.000000 l/h | 0.00 l/s | Y=13.85 | 00 | 3.00 m | 0.0 m\X\B3/h | 0.0 Pa | Top= 0.24m FCL | CC= 3.00m SSL | CC= 3.00m FFB | .000 | Extract Air | .0019 | wc | CC= 0.30m FCL | 11 | NN=2.80 m | 00.08 | NNUK=2.68 m | Edge= 2.94m SSL | 90.000000
Bend | X=19.56 | 0.00 m/s | 0.000000 l/h | 0.00 l/s | Y=14.54 | 00 | 3.00 m | 0.0 m\X\B3/h | 0.0 Pa | Top= 0.24m FCL | CC= 3.00m SSL | CC= 3.00m FFB | .000 | Extract Air | .0019 | wc | CC= 0.30m FCL | 11 | NN=2.80 m | 00.07 | NNUK=2.68 m | Edge= 2.94m SSL | 90.000000
Bend | X=21.44 | 0.00 m/s | 0.000000 l/h | 0.00 l/s | Y=13.30 | 00 | 3.00 m | 0.0 m\X\B3/h | 0.0 Pa | Top= 0.24m FCL | CC= 3.00m SSL | CC= 3.00m FFB | .000 | Extract Air | .0019 | corridor | CC= 0.30m FCL | 11 | NN=2.80 m | 00.04 | NNUK=2.67 m | Edge= 2.94m SSL | 90.000000
Bend | X=23.31 | 0.00 m/s | 0.000000 l/h | 0.00 l/s | Y=12.66 | 00 | 3.00 m | 0.0 m\X\B3/h | 0.0 Pa | Top= 0.24m FCL | CC= 3.00m SSL | CC= 3.00m FFB | .000 | Extract Air | .0019 | wc | CC= 0.30m FCL | 11 | NN=2.80 m | 00.10 | NNUK=2.68 m | Edge= 2.94m SSL | 90.000000
Bend | X=23.31 | 0.00 m/s | 0.000000 l/h | 0.00 l/s | Y=13.91 | 00 | 3.00 m | 0.0 m\X\B3/h | 0.0 Pa | Top= 0.24m FCL | CC= 3.00m SSL | CC= 3.00m FFB | .000 | Extract Air | .0019 | wc | CC= 0.30m FCL | 11 | NN=2.80 m | 00.09 | NNUK=2.68 m | Edge= 2.94m SSL | 90.000000
Bend | X=22.58 | 0.00 m/s | 0.000000 l/h | 0.00 l/s | Y=17.56 | 00 | 3.00 m | 0.0 m\X\B3/h | 0.0 Pa | Top= 0.24m FCL | CC= 3.00m SSL | CC= 3.00m FFB | .000 | Extract Air | .0019 | Storage | CC= 0.30m FCL | 11 | NN=2.80 m | 00.22 | NNUK=2.68 m | Edge= 2.94m SSL | 180.000000
Bend | X=10.94 | 0.00 m/s | 0.000000 l/h | 0.00 l/s | Y=13.19 | 00 | 3.10 m | 0.0 m\X\B3/h | 0.0 Pa | Top= 0.14m FCL | CC= 3.10m SSL | CC= 3.10m FFB | .000 | Extract Air | .0019 | Storage | CC= 0.20m FCL | 11 | NN=2.90 m | 00.13 | NNUK=2.77 m | Edge= 3.04m SSL | 270.000000

# IfcFlowFitting: BE83001250xx (4)
In: 00 Ground floor
Type - Description: Folded Spiral-Seam Circ free d 125; PredefinedType: BEND
Type - Pset_ManufacturerTypeInformation - ArticleNumber: BE83001250xx; ModelReference: Folded Spiral-Seam Circ free d 125; Manufacturer: DDS
Type - Pset_DuctFittingTypeCommon - NominalDiameterOrWidth: 125; NominalHeight: 300
Material: IFC Building Material
Pset_DDS - Manufacturer: DDS; Width: 125; Ins thickness: ins= 0.000000 mm; Dimension DN: 125 mm; Model Number: Dra.no: 1; Length: 125.0 m; Product Number: BE83001250xx; Project name: OpenBIM; Height: 0; Insulation k-value: 0; Pressure drop: 0; Insulation WSVO: 0; Product: Folded Spiral-Seam Circ free d 125; Floor number: Storey: 2; Pipe thickness:: x0.0; Outside dimension: 125.000000; Building Part: Building: 0
AC_Pset_RenovationAndPhasing - Renovation Status: Existing
Name | Mtg. Above Slab ref Center | Above Sea Level ref. Bottom | Mounting Height | Velocity | Above Sea Level ref. Center | Flow (l/h) | Flow (l/s) | Main string number | Rotation | Abs. pressure | Flow (m\X\B3/h) | Part number | Medium | Mtg. Below Ceiling ref Center | Room tekst | Mtg. Above Slab ref Bottom | Layer number | X | Sub string number | Room number | Y | Mtg. Below Ceiling ref Top | Mtg. above Finished Floor ref Center
1.22.-2 | CC= 3.12m SSL | NNUK=2.68 m | 3.00 m | 2.44 m/s | NN=2.80 m | 108000.000000 l/h | 30.00 l/s | 01 | 89.999997 | 224.7 Pa | 108.0 m\X\B3/h | .-002 | Supply Air | CC= 0.18m FCL | Office | Edge= 3.06m SSL | 10 | X=34.97 | .0022 | 00.23 | Y=18.08 | Top= 0.12m FCL | CC= 3.12m FFB | Pset_DDS - System Name: Supply Air; Group: Supply air
1.22.-4 | CC= 2.96m SSL | NNUK=2.52 m | 2.84 m | 2.44 m/s | NN=2.64 m | 108000.000000 l/h | 30.00 l/s | 01 | 269.999998 | 222.6 Pa | 108.0 m\X\B3/h | .-004 | Supply Air | CC= 0.34m FCL | Office | Edge= 2.90m SSL | 10 | X=34.97 | .0022 | 00.23 | Y=17.76 | Top= 0.27m FCL | CC= 2.96m FFB | Pset_DDS - System Name: Supply Air; Group: Supply air
Bend | CC= 3.00m SSL | NNUK=2.68 m | 3.00 m | 0.00 m/s | NN=2.80 m | 0.000000 l/h | 0.00 l/s | 00 | 0.000000 | 0.0 Pa | 0.0 m\X\B3/h | .000 | Extract Air | CC= 0.30m FCL | Hallway | Edge= 2.94m SSL | 11 | X=23.79 | .0019 | 00.03 | Y=12.94 | Top= 0.24m FCL | CC= 3.00m FFB
Bend | CC= 3.10m SSL | NNUK=2.77 m | 3.10 m | 0.00 m/s | NN=2.90 m | 0.000000 l/h | 0.00 l/s | 00 | 178.597880 | 0.0 Pa | 0.0 m\X\B3/h | .000 | Extract Air | CC= 0.20m FCL | Storage | Edge= 3.04m SSL | 11 | X=12.06 | .0019 | 00.13 | Y=13.02 | Top= 0.14m FCL | CC= 3.10m FFB

# IfcFlowFitting: BE8300140090 (2)
In: 00 Ground floor
Type - Description: Folded Spiral-Seam Circ Bend 90\X\B0 d 140; PredefinedType: BEND
Type - Pset_ManufacturerTypeInformation - ArticleNumber: BE8300140090; ModelReference: Folded Spiral-Seam Circ Bend 90\X\B0 d 140; Manufacturer: DDS
Type - Pset_DuctFittingTypeCommon - NominalDiameterOrWidth: 140; NominalHeight: 300
Material: IFC Building Material
Pset_DDS - Above Sea Level ref. Bottom: NNUK=2.66 m; Mounting Height: 3.00 m; Width: 140; Above Sea Level ref. Center: NN=2.80 m; Mtg. Below Ceiling ref Center: CC= 0.30m FCL; Mtg. above Finished Floor ref Center: CC= 3.00m FFB; Manufacturer: DDS; Mtg. Above Slab ref Center: CC= 3.00m SSL; Ins thickness: ins= 0.000000 mm; Mtg. Below Ceiling ref Top: Top= 0.23m FCL; Product: Folded Spiral-Seam Circ Bend 90\X\B0 d 140; Length: 140.0 m; Sub string number: .0019; Product Number: BE8300140090; Model Number: Dra.no: 1; Outside dimension: 140.000000; Layer number: 11; Main string number: 00; Project name: OpenBIM; Height: 0; Insulation k-value: 0; Pressure drop: 0; Insulation WSVO: 0; Flow (m\X\B3/h): 0.0 m\X\B3/h; Floor number: Storey: 2; Mtg. Above Slab ref Bottom: Edge= 2.93m SSL; Flow (l/h): 0.000000 l/h; Y: Y=12.65; Pipe thickness:: x0.0; Part number: .000; Dimension DN: 140 mm; Building Part: Building: 0; Flow (l/s): 0.00 l/s; Medium: Extract Air; Abs. pressure: 0.0 Pa; Velocity: 0.00 m/s
AC_Pset_RenovationAndPhasing - Renovation Status: Existing
Name | Room tekst | X | Room number | Rotation
Bend | corridor | X=20.21 | 00.04 | 0.000000
Bend | wc | X=19.56 | 00.06 | 90.000000

# IfcFlowFitting: BE8300250030 (2)
In: 00 Ground floor
Type - Description: Folded Spiral-Seam Circ Bend 30\X\B0 d 250; PredefinedType: BEND
Type - Pset_ManufacturerTypeInformation - ArticleNumber: BE8300250030; ModelReference: Folded Spiral-Seam Circ Bend 30\X\B0 d 250; Manufacturer: DDS
Type - Pset_DuctFittingTypeCommon - NominalDiameterOrWidth: 250; NominalHeight: 300
Material: IFC Building Material; Group: Supply air
Pset_DDS - Mounting Height: 3.00 m; Above Sea Level ref. Center: NN=2.80 m; Mtg. Below Ceiling ref Center: CC= 0.30m FCL; Velocity: 2.26 m/s; Outside dimension: 250.000000; Main string number: 01; Mtg. Above Slab ref Bottom: Edge= 2.88m SSL; Mtg. above Finished Floor ref Center: CC= 3.00m FFB; Manufacturer: DDS; Mtg. Above Slab ref Center: CC= 3.00m SSL; Ins thickness: ins= 0.000000 mm; Flow (m\X\B3/h): 400.0 m\X\B3/h; Product: Folded Spiral-Seam Circ Bend 30\X\B0 d 250; System Name: Supply Air; Medium: Supply Air; Length: 250.0 m; Sub string number: .0011; Room number: 00.13; Model Number: Dra.no: 1; Product Number: BE8300250030; Layer number: 10; Room tekst: Storage; Project name: OpenBIM; Height: 0; Insulation k-value: 0; Pressure drop: 0; Insulation WSVO: 0; Dimension DN: 250 mm; Floor number: Storey: 2; Width: 250; Flow (l/s): 111.11 l/s; Pipe thickness:: x0.0; Above Sea Level ref. Bottom: NNUK=2.55 m; Mtg. Below Ceiling ref Top: Top= 0.17m FCL; Building Part: Building: 0; Flow (l/h): 400000.000000 l/h
AC_Pset_RenovationAndPhasing - Renovation Status: Existing
Name | Rotation | X | Part number | Abs. pressure | Y
1.11.11 | 180.000000 | X=12.20 | .011 | 62.0 Pa | Y=14.50
1.11.13 | 0.000000 | X=10.85 | .013 | 60.0 Pa | Y=13.72

# IfcFlowFitting: BE8300250090, 1.11.3
In: 00 Ground floor
Type - Description: Folded Spiral-Seam Circ Bend 90\X\B0 d 250; PredefinedType: BEND
Type - Pset_ManufacturerTypeInformation - ArticleNumber: BE8300250090; ModelReference: Folded Spiral-Seam Circ Bend 90\X\B0 d 250; Manufacturer: DDS
Type - Pset_DuctFittingTypeCommon - NominalDiameterOrWidth: 250; NominalHeight: 300
Material: IFC Building Material; Group: Supply air
Pset_DDS - Mounting Height: 3.00 m; Above Sea Level ref. Center: NN=2.80 m; Product: Folded Spiral-Seam Circ Bend 90\X\B0 d 250; Part number: .003; Mtg. Below Ceiling ref Center: CC= 0.30m FCL; Velocity: 5.66 m/s; X: X=18.47; Outside dimension: 250.000000; Main string number: 01; Flow (l/s): 277.78 l/s; Mtg. Above Slab ref Bottom: Edge= 2.88m SSL; Flow (l/h): 1000000.000000 l/h; Mtg. above Finished Floor ref Center: CC= 3.00m FFB; Manufacturer: DDS; Mtg. Above Slab ref Center: CC= 3.00m SSL; Ins thickness: ins= 0.000000 mm; Flow (m\X\B3/h): 1000.0 m\X\B3/h; System Name: Supply Air; Medium: Supply Air; Length: 250.0 m; Sub string number: .0011; Room number: 00.18; Room tekst: Office; Model Number: Dra.no: 1; Product Number: BE8300250090; Layer number: 10; Abs. pressure: 69.6 Pa; Project name: OpenBIM; Height: 0; Insulation k-value: 0; Pressure drop: 0; Insulation WSVO: 0; Dimension DN: 250 mm; Floor number: Storey: 2; Width: 250; Pipe thickness:: x0.0; Above Sea Level ref. Bottom: NNUK=2.55 m; Mtg. Below Ceiling ref Top: Top= 0.17m FCL; Rotation: 0.000000; Building Part: Building: 0; Y: Y=14.50
AC_Pset_RenovationAndPhasing - Renovation Status: Existing

# IfcFlowFitting: BE8300315015 (2)
In: 00 Ground floor
Type - Description: Folded Spiral-Seam Circ Bend 15\X\B0 d 315; PredefinedType: BEND
Type - Pset_ManufacturerTypeInformation - ArticleNumber: BE8300315015; ModelReference: Folded Spiral-Seam Circ Bend 15\X\B0 d 315; Manufacturer: DDS
Type - Pset_DuctFittingTypeCommon - NominalDiameterOrWidth: 315; NominalHeight: 300
Material: IFC Building Material; Group: Supply air
Pset_DDS - Dimension DN: 315 mm; Mounting Height: 3.00 m; Velocity: 7.84 m/s; Above Sea Level ref. Center: NN=2.80 m; Above Sea Level ref. Bottom: NNUK=2.49 m; Product: Folded Spiral-Seam Circ Bend 15\X\B0 d 315; Mtg. Below Ceiling ref Center: CC= 0.30m FCL; Main string number: 01; Width: 315; Mtg. Above Slab ref Bottom: Edge= 2.84m SSL; Mtg. above Finished Floor ref Center: CC= 3.00m FFB; Manufacturer: DDS; Mtg. Above Slab ref Center: CC= 3.00m SSL; Ins thickness: ins= 0.000000 mm; System Name: Supply Air; Outside dimension: 315.000000; Medium: Supply Air; Model Number: Dra.no: 1; Length: 315.0 m; Layer number: 10; Project name: OpenBIM; Height: 0; Insulation k-value: 0; Pressure drop: 0; Insulation WSVO: 0; Floor number: Storey: 2; Room tekst: Hallway; Flow (l/s): 611.11 l/s; Flow (l/h): 2200000.000000 l/h; Pipe thickness:: x0.0; Sub string number: .0004; Room number: 00.03; Mtg. Below Ceiling ref Top: Top= 0.14m FCL; Building Part: Building: 0; Flow (m\X\B3/h): 2200.0 m\X\B3/h; Product Number: BE8300315015
AC_Pset_RenovationAndPhasing - Renovation Status: Existing
Name | Abs. pressure | Rotation | X | Part number | Y
1.4.7 | 145.9 Pa | 180.000000 | X=24.82 | .007 | Y=18.32
1.4.9 | 127.0 Pa | 0.000000 | X=24.56 | .009 | Y=18.25

# IfcFlowFitting: BE83051600xx (36)
Type - Description: Flexible Circular Duct free DN 160; PredefinedType: BEND
Type - Pset_ManufacturerTypeInformation - ArticleNumber: BE83051600xx; ModelReference: Flexible Circular Duct free DN 160; Manufacturer: DDS
Type - Pset_DuctFittingTypeCommon - NominalDiameterOrWidth: 160; NominalHeight: 300
Material: IFC Building Material; Group: Supply air
Pset_DDS - Dimension DN: 160 mm; Velocity: 2.76 m/s; Main string number: 01; Manufacturer: DDS; Ins thickness: ins= 0.000000 mm; Flow (m\X\B3/h): 200.0 m\X\B3/h; Product Number: BE83051600xx; System Name: Supply Air; Medium: Supply Air; Length: 160.0 m; Flow (l/s): 55.56 l/s; Layer number: 10; Project name: OpenBIM; Flow (l/h): 200000.000000 l/h; Height: 0; Insulation k-value: 0; Pressure drop: 0; Insulation WSVO: 0; Outside dimension: 160.000000; Pipe thickness:: x0.0; Width: 160; Product: Flexible Circular Duct free DN 160; Building Part: Building: 0
AC_Pset_RenovationAndPhasing - Renovation Status: Existing
Name | In | Rotation | Above Sea Level ref. Bottom | Mounting Height | X | Above Sea Level ref. Center | Mtg. Below Ceiling ref Center | Mtg. Above Slab ref Bottom | Mtg. above Finished Floor ref Center | Mtg. Above Slab ref Center | Mtg. Below Ceiling ref Top | Sub string number | Room tekst | Model Number | Part number | Y | Room number | Abs. pressure | Floor number
1.10.2 | 00 Ground floor | 90.000000 | NNUK=2.64 m | 3.00 m | X=18.19 | NN=2.80 m | CC= 0.30m FCL | Edge= 2.92m SSL | CC= 3.00m FFB | CC= 3.00m SSL | Top= 0.22m FCL | .0010 | Office | Dra.no: 1 | .002 | Y=18.54 | 001 | 100.4 Pa | Storey: 2
1.10.4 | 00 Ground floor | 270.000000 | NNUK=2.49 m | 2.85 m | X=18.19 | NN=2.65 m | CC= 0.45m FCL | Edge= 2.77m SSL | CC= 2.85m FFB | CC= 2.85m SSL | Top= 0.37m FCL | .0010 | Office | Dra.no: 1 | .004 | Y=19.57 | 001 | 96.8 Pa | Storey: 2
1.12.2 | 00 Ground floor | 90.000000 | NNUK=2.64 m | 3.00 m | X=6.75 | NN=2.80 m | CC= 0.30m FCL | Edge= 2.92m SSL | CC= 3.00m FFB | CC= 3.00m SSL | Top= 0.22m FCL | .0012 | Office | Dra.no: 1 | .002 | Y=13.52 | 00.19 | 54.8 Pa | Storey: 2
1.12.4 | 00 Ground floor | 270.000000 | NNUK=2.44 m | 2.80 m | X=6.75 | NN=2.60 m | CC= 0.50m FCL | Edge= 2.72m SSL | CC= 2.80m FFB | CC= 2.80m SSL | Top= 0.42m FCL | .0012 | Office | Dra.no: 1 | .004 | Y=12.72 | 00.19 | 51.5 Pa | Storey: 2
1.13.2 | 00 Ground floor | 90.000000 | NNUK=2.64 m | 3.00 m | X=8.63 | NN=2.80 m | CC= 0.30m FCL | Edge= 2.92m SSL | CC= 3.00m FFB | CC= 3.00m SSL | Top= 0.22m FCL | .0013 | Office | Dra.no: 1 | .002 | Y=13.52 | 00.19 | 53.4 Pa | Storey: 2
1.13.4 | 00 Ground floor | 270.000000 | NNUK=2.44 m | 2.80 m | X=8.63 | NN=2.60 m | CC= 0.50m FCL | Edge= 2.72m SSL | CC= 2.80m FFB | CC= 2.80m SSL | Top= 0.42m FCL | .0013 | Office | Dra.no: 1 | .004 | Y=12.72 | 00.19 | 50.1 Pa | Storey: 2
1.14.2 | 00 Ground floor | 90.000000 | NNUK=2.64 m | 3.00 m | X=13.75 | NN=2.80 m | CC= 0.30m FCL | Edge= 2.92m SSL | CC= 3.00m FFB | CC= 3.00m SSL | Top= 0.22m FCL | .0014 | Office | Dra.no: 1 | .002 | Y=14.30 | 00.17 | 55.4 Pa | Storey: 2
1.14.4 | 00 Ground floor | 270.000000 | NNUK=2.44 m | 2.80 m | X=13.75 | NN=2.60 m | CC= 0.50m FCL | Edge= 2.72m SSL | CC= 2.80m FFB | CC= 2.80m SSL | Top= 0.42m FCL | .0014 | Office | Dra.no: 1 | .004 | Y=13.44 | 00.17 | 52.0 Pa | Storey: 2
1.15.2 | 00 Ground floor | 90.000000 | NNUK=2.64 m | 3.00 m | X=15.94 | NN=2.80 m | CC= 0.30m FCL | Edge= 2.92m SSL | CC= 3.00m FFB | CC= 3.00m SSL | Top= 0.22m FCL | .0015 | Office | Dra.no: 1 | .002 | Y=14.30 | 00.18 | 52.9 Pa | Storey: 2
1.15.4 | 00 Ground floor | 270.000000 | NNUK=2.44 m | 2.80 m | X=15.94 | NN=2.60 m | CC= 0.50m FCL | Edge= 2.72m SSL | CC= 2.80m FFB | CC= 2.80m SSL | Top= 0.42m FCL | .0015 | Office | Dra.no: 1 | .004 | Y=13.44 | 00.18 | 49.5 Pa | Storey: 2
1.16.2 | 00 Ground floor | 90.000000 | NNUK=2.64 m | 3.00 m | X=17.81 | NN=2.80 m | CC= 0.30m FCL | Edge= 2.92m SSL | CC= 3.00m FFB | CC= 3.00m SSL | Top= 0.22m FCL | .0016 | Office | Dra.no: 1 | .002 | Y=14.30 | 00.18 | 49.2 Pa | Storey: 2
1.16.4 | 00 Ground floor | 270.000000 | NNUK=2.44 m | 2.80 m | X=17.81 | NN=2.60 m | CC= 0.50m FCL | Edge= 2.72m SSL | CC= 2.80m FFB | CC= 2.80m SSL | Top= 0.42m FCL | .0016 | Office | Dra.no: 1 | .004 | Y=13.44 | 00.18 | 45.8 Pa | Storey: 2
1.17.2 | 00 Ground floor | 90.000000 | NNUK=2.64 m | 3.00 m | X=20.06 | NN=2.80 m | CC= 0.30m FCL | Edge= 2.92m SSL | CC= 3.00m FFB | CC= 3.00m SSL | Top= 0.22m FCL | .0017 | Office | Dra.no: 1 | .002 | Y=18.54 | 001 | 79.7 Pa | Storey: 2
1.17.4 | 00 Ground floor | 270.000000 | NNUK=2.49 m | 2.85 m | X=20.06 | NN=2.65 m | CC= 0.45m FCL | Edge= 2.77m SSL | CC= 2.85m FFB | CC= 2.85m SSL | Top= 0.37m FCL | .0017 | Office | Dra.no: 1 | .004 | Y=19.57 | 001 | 76.1 Pa | Storey: 2
1.6.2 | 00 Ground floor | 90.000000 | NNUK=2.64 m | 3.00 m | X=9.53 | NN=2.80 m | CC= 0.30m FCL | Edge= 2.92m SSL | CC= 3.00m FFB | CC= 3.00m SSL | Top= 0.22m FCL | .0006 | Office | Dra.no: 1 | .002 | Y=18.54 | 00.20 | 104.1 Pa | Storey: 2
1.6.4 | 00 Ground floor | 270.000000 | NNUK=2.49 m | 2.85 m | X=9.53 | NN=2.65 m | CC= 0.45m FCL | Edge= 2.77m SSL | CC= 2.85m FFB | CC= 2.85m SSL | Top= 0.37m FCL | .0006 | Office | Dra.no: 1 | .004 | Y=19.57 | 00.20 | 100.5 Pa | Storey: 2
1.7.2 | 00 Ground floor | 90.000000 | NNUK=2.64 m | 3.00 m | X=10.78 | NN=2.80 m | CC= 0.30m FCL | Edge= 2.92m SSL | CC= 3.00m FFB | CC= 3.00m SSL | Top= 0.22m FCL | .0007 | Office | Dra.no: 1 | .002 | Y=18.54 | 00.20 | 103.4 Pa | Storey: 2
1.7.4 | 00 Ground floor | 270.000000 | NNUK=2.49 m | 2.85 m | X=10.78 | NN=2.65 m | CC= 0.45m FCL | Edge= 2.77m SSL | CC= 2.85m FFB | CC= 2.85m SSL | Top= 0.37m FCL | .0007 | Office | Dra.no: 1 | .004 | Y=19.57 | 00.20 | 99.8 Pa | Storey: 2
1.8.2 | 00 Ground floor | 90.000000 | NNUK=2.64 m | 3.00 m | X=13.69 | NN=2.80 m | CC= 0.30m FCL | Edge= 2.92m SSL | CC= 3.00m FFB | CC= 3.00m SSL | Top= 0.22m FCL | .0008 | Office | Dra.no: 1 | .002 | Y=18.54 | 00.21 | 102.6 Pa | Storey: 2
1.8.4 | 00 Ground floor | 270.000000 | NNUK=2.49 m | 2.85 m | X=13.69 | NN=2.65 m | CC= 0.45m FCL | Edge= 2.77m SSL | CC= 2.85m FFB | CC= 2.85m SSL | Top= 0.37m FCL | .0008 | Office | Dra.no: 1 | .004 | Y=19.57 | 00.21 | 99.0 Pa | Storey: 2
1.9.2 | 00 Ground floor | 90.000000 | NNUK=2.64 m | 3.00 m | X=15.56 | NN=2.80 m | CC= 0.30m FCL | Edge= 2.92m SSL | CC= 3.00m FFB | CC= 3.00m SSL | Top= 0.22m FCL | .0009 | Office | Dra.no: 1 | .002 | Y=18.54 | 00.21 | 101.5 Pa | Storey: 2
1.9.4 | 00 Ground floor | 270.000000 | NNUK=2.49 m | 2.85 m | X=15.56 | NN=2.65 m | CC= 0.45m FCL | Edge= 2.77m SSL | CC= 2.85m FFB | CC= 2.85m SSL | Top= 0.37m FCL | .0009 | Office | Dra.no: 1 | .004 | Y=19.57 | 00.21 | 97.9 Pa | Storey: 2
1.35.2 | 01 First floor | 90.000000 | NNUK=6.14 m | 3.00 m | X=8.91 | NN=6.30 m | CC= 0.18m FCL | Edge= 3.04m SSL | CC= 3.12m FFB | CC= 3.12m SSL | Top= 0.10m FCL | .0035 | Office | Dra.no: 2 | .002 | Y=18.69 | 01.18 | 282.1 Pa | Storey: 3
1.35.4 | 01 First floor | 270.000000 | NNUK=5.99 m | 2.85 m | X=8.91 | NN=6.15 m | CC= 0.33m FCL | Edge= 2.89m SSL | CC= 2.97m FFB | CC= 2.97m SSL | Top= 0.25m FCL | .0035 | Office | Dra.no: 2 | .004 | Y=19.57 | 01.18 | 278.7 Pa | Storey: 3
1.36.2 | 01 First floor | 90.000000 | NNUK=6.14 m | 3.00 m | X=11.41 | NN=6.30 m | CC= 0.18m FCL | Edge= 3.04m SSL | CC= 3.12m FFB | CC= 3.12m SSL | Top= 0.10m FCL | .0036 | Office | Dra.no: 2 | .002 | Y=18.69 | 01.18 | 281.8 Pa | Storey: 3
